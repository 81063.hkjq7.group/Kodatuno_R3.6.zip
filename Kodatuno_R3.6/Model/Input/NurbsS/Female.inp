16.008637,12.546745,16.683892
15.966959,12.936217,16.685984
15.912624,13.333391,16.680315
15.905872,13.780392,16.638643
15.971049,14.272231,16.573252
15.979330,14.727148,16.546859
15.919326,15.141249,16.542953
15.879623,15.573397,16.528936
15.867900,16.027129,16.530627
15.543251,16.270869,16.611835
15.070582,16.277862,16.681110
14.948256,16.591164,16.694888
14.981282,17.051027,16.685190
14.977900,17.483092,16.685137
15.055989,18.022697,16.557212
15.163080,18.577431,16.319607
15.228565,19.048172,16.050704
15.271187,19.463681,15.760468
15.303680,19.862650,15.459061
15.309708,20.253429,15.194450
15.320792,20.661088,15.002132
15.388631,21.101490,14.964426
15.507003,21.535262,15.149833
15.716800,21.963971,15.524912
15.974537,22.367949,16.003311
16.220856,22.772438,16.444847
16.397353,23.189943,16.728750
16.487802,23.624489,16.889531
16.537040,24.076565,16.972358
16.571419,24.530733,16.990178
16.582434,24.967829,16.953540
16.573017,25.391938,16.885389
16.558927,25.817086,16.812829
16.559239,26.251972,16.751616
16.576185,26.694496,16.698758
16.597928,27.137697,16.645496
16.615781,27.577845,16.584119
16.626926,28.013932,16.513615
16.630333,28.446169,16.441019
16.629081,28.877793,16.375574
16.629562,29.311596,16.315059
16.632367,29.743566,16.241920
16.630811,30.166853,16.141798
16.617979,30.579871,16.019964
16.599562,30.988066,15.886396
16.584038,31.396227,15.745903
16.570693,31.803872,15.601979
16.562474,32.210966,15.453938
16.561530,32.620023,15.302193
16.560395,33.033673,15.155520
16.554892,33.450343,15.016585
16.535981,33.855571,14.870277
16.512729,34.238282,14.687280
16.487864,34.598753,14.464472
16.445315,34.942527,14.226506
16.417951,35.283056,13.969805
16.405397,35.622997,13.694952
16.380457,35.962222,13.421067
16.365600,36.315834,13.175093
16.373626,36.707557,13.017339
16.400810,37.143849,12.973972
16.416244,37.595594,12.990035
16.414063,38.038115,13.000062
16.400714,38.472766,12.998600
16.385809,38.909412,12.998848
16.377984,39.350073,13.001090
16.470588,39.909433,13.000000
16.941176,0.000000,13.000000
16.934408,0.435464,12.997583
16.934005,0.866338,13.003662
16.930790,1.303330,12.998332
16.912517,1.740539,12.994460
16.918268,2.170444,13.002270
16.864466,2.601654,13.011990
16.792715,3.049649,12.997733
16.642059,3.526938,12.960073
16.505259,3.950212,13.013256
16.417912,4.246045,13.247882
16.410440,4.455626,13.586500
16.429844,4.612269,13.977818
16.480689,4.774563,14.370193
16.551920,5.014921,14.710918
16.584206,5.337924,15.000805
16.597356,5.717567,15.229889
16.602504,6.108304,15.419259
16.623777,6.514059,15.556445
16.669915,6.953267,15.624788
16.691553,7.402131,15.672402
16.699899,7.846767,15.730462
16.755247,8.294562,15.796656
16.842787,8.744450,15.859790
16.880439,9.182578,15.912736
16.822841,9.598820,15.967995
16.670742,9.984870,16.047115
16.572820,10.366661,16.121605
16.585213,10.759893,16.231437
16.599419,11.149026,16.371572
16.621517,11.574563,16.420661
16.599555,12.007696,16.395589
16.498501,12.402661,16.392602
16.449366,12.814687,16.389828
16.413536,13.213516,16.413666
16.371558,13.613391,16.435966
16.375755,14.060438,16.424208
16.449636,14.553779,16.387415
16.462719,15.005506,16.378878
16.406105,15.415953,16.380781
16.369028,15.843257,16.361546
16.360528,16.291368,16.350142
16.068496,16.620880,16.460437
15.579283,16.739450,16.555730
15.423107,17.042120,16.519977
15.443126,17.501854,16.451439
15.415331,17.912193,16.381051
15.474047,18.399939,16.205192
15.573639,18.885012,15.933196
15.644172,19.321448,15.657557
15.692634,19.752100,15.393854
15.733724,20.191894,15.156766
15.759133,20.620128,14.985800
15.793949,21.040965,14.912841
15.873629,21.464525,14.975909
15.996663,21.867047,15.205118
16.202776,22.246496,15.619300
16.463449,22.603056,16.115061
16.721983,22.967354,16.509324
16.903273,23.375664,16.745509
16.988438,23.826716,16.862640
17.029536,24.288105,16.888190
17.057893,24.732242,16.846365
17.066161,25.154816,16.774094
17.053691,25.572315,16.703543
17.036985,25.996969,16.644394
17.035691,26.429804,16.591391
17.051545,26.866003,16.537855
17.072372,27.300968,16.478767
17.088766,27.733522,16.410052
17.097131,28.162937,16.331511
17.096490,28.588722,16.250427
17.091065,29.014144,16.177878
17.088879,29.442060,16.111536
17.089920,29.868068,16.032847
17.085123,30.284860,15.926255
17.068158,30.692266,15.799431
17.046130,31.096243,15.664494
17.028677,31.501315,15.527015
17.014509,31.906594,15.388455
17.005822,32.311517,15.245416
17.004219,32.717729,15.096258
17.000346,33.126540,14.947961
16.990282,33.534486,14.800724
16.966973,33.929581,14.644080
16.941249,34.303431,14.456223
16.913832,34.656141,14.232423
16.863316,34.989975,13.988349
16.825828,35.318746,13.720272
16.813164,35.656513,13.446848
16.804043,36.013729,13.211611
16.809544,36.398062,13.039620
16.831317,36.816704,12.965414
16.860497,37.263382,12.981133
16.872152,37.711192,13.016421
16.872069,38.145147,13.014554
16.863388,38.571551,12.993284
16.851528,39.003197,12.991148
16.845339,39.441890,13.007903
16.941176,39.909433,13.000000
17.411765,0.000000,13.000000
17.405498,0.428994,13.001054
17.405120,0.862378,12.997289
17.402057,1.288002,13.002567
17.384999,1.718175,13.002597
17.390733,2.154250,12.995173
17.340483,2.588719,12.993448
17.269960,3.011507,13.005717
17.131610,3.451694,13.001551
17.005505,3.915004,12.981364
16.871758,4.337960,13.039694
16.782603,4.649443,13.252780
16.762119,4.841247,13.611805
16.829250,4.997939,14.017631
16.928460,5.225625,14.363055
16.971301,5.540019,14.643847
16.987603,5.919222,14.861910
17.001783,6.313957,15.051482
17.036652,6.720238,15.199614
17.097699,7.155336,15.283611
17.135420,7.596987,15.350573
17.160999,8.034552,15.429003
17.225639,8.476325,15.510802
17.306282,8.920367,15.576986
17.343724,9.354992,15.629555
17.300342,9.765326,15.704607
17.182636,10.150016,15.829153
17.120576,10.551448,15.940827
17.101849,10.974006,16.013859
17.057150,11.399455,16.061602
17.044312,11.838333,16.073869
17.044490,12.266521,16.100986
16.987511,12.665467,16.150928
16.955183,13.085221,16.167257
16.908221,13.501029,16.192196
16.867653,13.915196,16.221824
16.883312,14.356386,16.229149
16.962443,14.826497,16.213233
16.974395,15.264567,16.214307
16.921469,15.674437,16.224017
16.893694,16.091817,16.202324
16.867889,16.508693,16.152684
16.575329,16.844497,16.228047
16.134189,17.130188,16.414651
15.971359,17.487349,16.395361
15.964335,17.923613,16.253960
15.901848,18.310866,16.098272
15.938372,18.724404,15.867312
16.045340,19.147013,15.598714
16.138249,19.575816,15.386718
16.204595,20.023172,15.235743
16.251559,20.476578,15.117944
16.279918,20.918369,15.020220
16.310329,21.346008,14.986009
16.372091,21.757026,15.076980
16.480994,22.132895,15.333630
16.691916,22.472118,15.758967
16.972434,22.785467,16.198863
17.252907,23.130315,16.512280
17.441183,23.544088,16.692954
17.521886,24.001051,16.756442
17.554392,24.459629,16.743110
17.579674,24.893388,16.688352
17.589783,25.307270,16.615628
17.575289,25.719588,16.538909
17.551127,26.139730,16.467433
17.541981,26.566216,16.401681
17.553590,26.993935,16.339238
17.573333,27.420098,16.275207
17.589638,27.844997,16.203620
17.597626,28.268602,16.123913
17.596227,28.690603,16.044991
17.588932,29.112509,15.975292
17.583234,29.534465,15.906016
17.579295,29.952150,15.818326
17.569011,30.361374,15.703546
17.547316,30.764276,15.574003
17.521862,31.165722,15.440280
17.502081,31.567959,15.303605
17.484455,31.969480,15.164504
17.471629,32.370585,15.022503
17.470033,32.774858,14.879680
17.470785,33.184301,14.743864
17.462395,33.589859,14.604483
17.431456,33.976130,14.441983
17.392916,34.337077,14.238372
17.353900,34.679442,13.998236
17.292013,35.009768,13.741794
17.249625,35.338708,13.472024
17.246899,35.686813,13.226885
17.257358,36.070873,13.064689
17.276500,36.485940,12.984500
17.302441,36.920464,12.972351
17.331574,37.362188,12.998516
17.342514,37.798396,13.019812
17.343268,38.227009,13.013156
17.335806,38.652344,12.994718
17.325304,39.081043,12.992432
17.320625,39.514375,13.006738
17.411765,39.909433,13.000000
17.882353,0.000000,13.000000
17.876389,0.425008,13.002043
17.875872,0.854952,12.996681
17.873205,1.278071,13.001623
17.856965,1.703286,13.004056
17.862270,2.134031,12.997481
17.815112,2.566249,12.992179
17.752149,2.988798,13.002111
17.621433,3.412716,13.014402
17.506823,3.866057,12.990390
17.363721,4.340535,12.956035
17.217375,4.744697,13.035140
17.148601,5.010633,13.299065
17.194007,5.209901,13.652777
17.278452,5.460285,13.965742
17.319761,5.776386,14.239737
17.352836,6.146778,14.466017
17.386486,6.532137,14.671586
17.435270,6.930495,14.839367
17.513430,7.356212,14.945452
17.572878,7.786267,15.037584
17.613524,8.214447,15.132928
17.677463,8.650440,15.212599
17.751216,9.090260,15.270070
17.793215,9.521321,15.330796
17.769314,9.932167,15.425798
17.671717,10.320738,15.565212
17.619591,10.727600,15.680813
17.599600,11.154668,15.743187
17.556506,11.583075,15.782998
17.547209,12.015844,15.807526
17.551602,12.440684,15.854722
17.507071,12.850964,15.924841
17.487204,13.274254,15.961946
17.443651,13.697737,15.998759
17.406095,14.121189,16.035080
17.426120,14.553900,16.049903
17.502795,14.997688,16.036535
17.510949,15.427352,16.033753
17.458668,15.844012,16.044131
17.434243,16.260887,16.026314
17.403469,16.668514,15.969583
17.097063,16.996474,15.984996
16.672030,17.318336,16.120583
16.522508,17.713406,16.118025
16.512766,18.127023,15.967481
16.448185,18.515486,15.800147
16.485113,18.913828,15.576887
16.610710,19.347444,15.378050
16.727792,19.804175,15.289493
16.809521,20.252774,15.287875
16.850490,20.684776,15.283685
16.861839,21.117873,15.214431
16.863864,21.552776,15.144722
16.896432,21.966542,15.204462
16.997418,22.325389,15.457141
17.227626,22.633665,15.832926
17.532759,22.928001,16.178039
17.820825,23.273169,16.438218
18.004972,23.680839,16.574688
18.078527,24.126418,16.592623
18.102412,24.572299,16.559429
18.123743,24.993804,16.511969
18.133110,25.400333,16.447127
18.114383,25.808222,16.360050
18.080165,26.222723,16.264289
18.059088,26.640833,16.174342
18.061716,27.058562,16.096110
18.075905,27.475223,16.023465
18.089117,27.892353,15.947458
18.096079,28.310828,15.868117
18.095379,28.730879,15.796294
18.088461,29.151678,15.735658
18.080431,29.569488,15.667990
18.071543,29.980096,15.573573
18.056541,30.383607,15.453239
18.032048,30.784379,15.324535
18.005328,31.185382,15.195307
17.984618,31.585784,15.060387
17.964282,31.983783,14.920027
17.947341,32.380994,14.778319
17.945782,32.783552,14.642375
17.952234,33.194939,14.521689
17.947083,33.600559,14.394756
17.909579,33.979996,14.230306
17.857017,34.327896,14.009654
17.806729,34.660498,13.750768
17.740865,34.994772,13.489257
17.705845,35.338649,13.241110
17.722808,35.710274,13.058307
17.751357,36.121892,12.990061
17.772311,36.555507,12.992242
17.792285,36.989600,13.004185
17.821100,37.417278,13.003366
17.834657,37.841822,12.997574
17.835259,38.269072,12.998460
17.826819,38.697244,13.001647
17.816694,39.123460,13.001035
17.812968,39.548770,12.998778
17.882353,39.909433,13.000000
18.352941,0.000000,13.000000
18.347352,0.422330,13.001411
18.346744,0.846928,12.998412
18.344443,1.269616,12.999900
18.329227,1.691754,13.002302
18.333999,2.115145,13.000791
18.290069,2.542119,12.997203
18.235260,2.970070,12.997110
18.111939,3.395088,13.007277
18.005340,3.822857,13.009336
17.881696,4.275725,12.978786
17.727655,4.724041,12.971432
17.620496,5.092417,13.086337
17.596189,5.392696,13.305857
17.619554,5.698926,13.549789
17.646837,6.026545,13.812616
17.701894,6.383215,14.052893
17.756366,6.750324,14.275821
17.815525,7.134057,14.458915
17.907369,7.545292,14.579032
17.984247,7.960773,14.688899
18.035531,8.377149,14.794409
18.096946,8.803086,14.865434
18.168081,9.231932,14.917193
18.218267,9.652270,14.993212
18.216629,10.061715,15.108629
18.138125,10.458698,15.253419
18.085622,10.864659,15.358697
18.083043,11.280646,15.431468
18.075151,11.693392,15.510416
18.088299,12.111617,15.568295
18.087741,12.533647,15.613651
18.037299,12.951390,15.679773
18.023544,13.371967,15.733768
17.996108,13.790349,15.792201
17.967074,14.210180,15.841230
17.985137,14.636462,15.856988
18.052783,15.068392,15.834998
18.057210,15.495911,15.825117
18.005325,15.917930,15.832290
17.978628,16.339764,15.822161
17.958886,16.761554,15.791015
17.669780,17.135130,15.804564
17.234677,17.442203,15.834503
17.086440,17.819239,15.789893
17.084044,18.217520,15.657888
17.037246,18.607888,15.520337
17.086702,19.037401,15.358203
17.220404,19.510758,15.256116
17.341905,19.978054,15.262181
17.425313,20.407715,15.327470
17.460010,20.822526,15.365395
17.460245,21.257961,15.319651
17.446748,21.702813,15.248532
17.472194,22.113028,15.284925
17.585351,22.446949,15.493126
17.824419,22.728509,15.784385
18.126080,23.017230,16.074907
18.399317,23.345429,16.312126
18.570306,23.731985,16.415535
18.636393,24.167528,16.413090
18.654271,24.603555,16.368240
18.667507,25.011976,16.307761
18.666895,25.408168,16.227439
18.637595,25.810635,16.127329
18.592340,26.221032,16.018388
18.558887,26.632406,15.911604
18.547863,27.040753,15.813813
18.549097,27.448320,15.722473
18.552892,27.858553,15.633111
18.555255,28.272860,15.549026
18.553646,28.691497,15.480822
18.547404,29.112380,15.428178
18.539424,29.529535,15.366511
18.529181,29.938546,15.274028
18.512870,30.341513,15.155613
18.488100,30.743691,15.031730
18.461576,31.146733,14.909949
18.441123,31.547886,14.782498
18.421634,31.946125,14.649495
18.405118,32.343110,14.513582
18.402071,32.743525,14.379174
18.403722,33.150887,14.255219
18.392671,33.551402,14.122009
18.350825,33.926523,13.952085
18.295852,34.271123,13.729537
18.251201,34.605907,13.480981
18.203472,34.956628,13.257093
18.188208,35.327451,13.074729
18.220700,35.725818,12.974425
18.258335,36.152376,12.973225
18.277129,36.587318,13.009740
18.291002,37.013570,13.020982
18.318243,37.431137,13.002010
18.332749,37.849626,12.985085
18.333340,38.274682,12.990739
18.324838,38.702199,13.004788
18.315326,39.125942,13.005555
18.312073,39.546153,12.994672
18.352941,39.909433,13.000000
18.823529,0.000000,13.000000
18.818494,0.420260,13.000143
18.817937,0.840518,13.000032
18.815854,1.261221,12.999745
18.802130,1.681606,13.000155
18.806446,2.101320,13.000645
18.766352,2.523078,13.000216
18.716216,2.947899,12.998225
18.604215,3.374147,13.000635
18.506199,3.792777,13.011169
18.400143,4.216794,13.009140
18.263759,4.662318,12.983219
18.145586,5.100725,12.983141
18.053326,5.501740,13.056646
18.005622,5.872904,13.207025
18.006572,6.224909,13.425614
18.064058,6.578287,13.648255
18.120448,6.935377,13.859557
18.179000,7.308772,14.032921
18.271310,7.706490,14.143488
18.349534,8.108143,14.251979
18.406394,8.510909,14.361246
18.474239,8.920149,14.436328
18.551701,9.328829,14.504073
18.612798,9.731513,14.601880
18.632896,10.131751,14.736390
18.586769,10.530044,14.899732
18.553960,10.933169,15.017725
18.567484,11.340007,15.106718
18.579156,11.745352,15.204233
18.603106,12.156991,15.274931
18.606185,12.575390,15.324984
18.562737,12.993887,15.394105
18.552142,13.411854,15.453757
18.532109,13.827031,15.522647
18.511155,14.242969,15.582438
18.529909,14.664109,15.604267
18.590621,15.088503,15.585874
18.593970,15.511893,15.581735
18.546236,15.933977,15.592986
18.520738,16.356072,15.589466
18.507406,16.782234,15.572965
18.256924,17.211648,15.620115
17.845573,17.582856,15.649303
17.689672,17.955620,15.563260
17.680738,18.347709,15.422745
17.642769,18.739861,15.306470
17.700543,19.179179,15.211682
17.828916,19.640685,15.177406
17.942087,20.072778,15.203627
18.024317,20.474778,15.249604
18.060131,20.886762,15.276391
18.059338,21.333976,15.257550
18.046290,21.785752,15.229933
18.082253,22.182562,15.272482
18.208461,22.492936,15.435904
18.433768,22.761015,15.677459
18.712568,23.033555,15.945435
18.963282,23.331761,16.142066
19.118040,23.703471,16.216762
19.177238,24.135066,16.211527
19.191011,24.566208,16.160412
19.195565,24.966794,16.078230
19.183803,25.356015,15.974847
19.144088,25.754298,15.863684
19.089671,26.161418,15.751247
19.046370,26.567975,15.637812
19.022601,26.969839,15.525034
19.009859,27.371148,15.414803
19.001814,27.776424,15.309461
18.996131,28.187111,15.215974
18.989448,28.603284,15.143914
18.980476,29.022994,15.091739
18.971577,29.440256,15.033643
18.961019,29.850350,14.945940
18.944002,30.254787,14.831784
18.917720,30.658336,14.711218
18.888948,31.062474,14.593741
18.867126,31.464699,14.474187
18.849638,31.865619,14.353377
18.836328,32.265573,14.227280
18.830086,32.663636,14.089337
18.817462,33.061427,13.945687
18.792042,33.451851,13.790122
18.746889,33.824615,13.611442
18.701033,34.177281,13.405092
18.680821,34.529674,13.205756
18.675049,34.909158,13.073544
18.687973,35.313385,13.004685
18.721866,35.732088,12.984845
18.756952,36.154806,12.992663
18.776128,36.576262,13.003548
18.790152,36.995678,13.005107
18.814613,37.413989,12.999999
18.826550,37.833501,12.996858
18.827771,38.253797,12.997853
18.821245,38.674752,13.000651
18.813004,39.095754,13.001217
18.809891,39.516016,12.998935
18.823529,39.909433,13.000000
19.294118,0.000000,13.000000
19.289664,0.418875,12.999336
19.289210,0.836751,13.000777
19.287315,1.255441,13.000146
19.275187,1.674722,12.998976
19.279109,2.093229,12.999487
19.243167,2.511526,13.001007
19.196571,2.930113,13.001355
19.097548,3.352908,12.998616
19.009749,3.775800,12.998502
18.909222,4.195594,13.003973
18.786986,4.622126,12.999474
18.684997,5.061456,12.980240
18.577615,5.499796,12.975891
18.487446,5.918334,13.024939
18.450809,6.309616,13.140926
18.468321,6.686279,13.281613
18.492365,7.058233,13.431309
18.537156,7.436130,13.563943
18.618185,7.828255,13.652888
18.685877,8.221788,13.753345
18.747184,8.613891,13.867468
18.829572,9.007769,13.963068
18.916613,9.399403,14.058372
18.985460,9.789147,14.171616
19.019960,10.179775,14.314013
19.007098,10.570775,14.496069
19.006015,10.968214,14.640906
19.029724,11.371399,14.742940
19.045059,11.778064,14.836058
19.069748,12.189551,14.906303
19.084829,12.602375,14.975141
19.063911,13.014770,15.060788
19.060509,13.429675,15.123860
19.041728,13.844553,15.195150
19.028280,14.259700,15.262823
19.053764,14.676304,15.299907
19.113460,15.094145,15.301200
19.118518,15.512173,15.311638
19.077024,15.930630,15.331458
19.055951,16.348483,15.331598
19.040258,16.765275,15.311044
18.820024,17.194146,15.366007
18.461402,17.632052,15.437590
18.311796,18.036028,15.357730
18.293951,18.429436,15.208241
18.257698,18.830823,15.104393
18.315950,19.252622,15.043443
18.436463,19.674772,15.024902
18.547370,20.076579,15.045212
18.633124,20.466476,15.081359
18.669204,20.874252,15.103082
18.662738,21.316346,15.089898
18.644430,21.761613,15.084573
18.682755,22.151547,15.144452
18.809425,22.467884,15.302407
19.016912,22.742900,15.530965
19.269729,22.995416,15.759896
19.494991,23.275099,15.907344
19.634523,23.637893,15.967272
19.687623,24.061002,15.965306
19.697513,24.488469,15.915237
19.697347,24.890812,15.828060
19.683099,25.283146,15.719747
19.642481,25.683366,15.607770
19.586866,26.090959,15.496865
19.541414,26.497132,15.385356
19.514331,26.898232,15.273299
19.496310,27.297969,15.160764
19.480104,27.700232,15.048369
19.464068,28.106734,14.944176
19.446482,28.518144,14.859724
19.428275,28.933539,14.796331
19.413310,29.347956,14.731187
19.399185,29.756570,14.640867
19.378423,30.159480,14.525167
19.346328,30.560299,14.400736
19.310384,30.960946,14.277744
19.283662,31.361050,14.155557
19.265160,31.762973,14.037702
19.252046,32.165440,13.916584
19.242515,32.562212,13.776697
19.219927,32.953157,13.622595
19.186539,33.338062,13.460950
19.146955,33.714988,13.295370
19.119285,34.084879,13.131896
19.126589,34.462940,13.005665
19.159367,34.870117,12.968798
19.193854,35.298413,12.994757
19.221882,35.726152,13.021669
19.250686,36.140105,13.013889
19.270673,36.549803,12.992238
19.286271,36.966072,12.986933
19.307821,37.387886,12.998925
19.316949,37.809395,13.009394
19.318788,38.226185,13.005481
19.314347,38.641713,12.996617
19.307516,39.060541,12.996500
19.304665,39.481657,13.003491
19.294118,39.909433,13.000000
19.764706,0.000000,13.000000
19.760746,0.418123,12.999642
19.760361,0.835746,13.000378
19.758720,1.253665,13.000160
19.747977,1.672014,12.999452
19.751535,2.090101,12.999547
19.719687,2.507738,13.000437
19.678258,2.924575,13.001387
19.590619,3.343494,12.999120
19.513105,3.766852,12.993392
19.419546,4.189047,12.994570
19.307705,4.604166,13.006061
19.226035,5.019138,13.011086
19.139251,5.443760,12.999838
19.045926,5.874008,12.984749
18.978768,6.299574,12.987027
18.936258,6.715431,13.018215
18.914729,7.118422,13.085145
18.940528,7.512376,13.165533
19.002965,7.908055,13.230555
19.054749,8.302017,13.313935
19.113652,8.692508,13.418842
19.198879,9.082655,13.520393
19.283309,9.472647,13.620415
19.348106,9.864343,13.723723
19.382520,10.254612,13.851969
19.384000,10.639445,14.030645
19.400572,11.032152,14.186224
19.431036,11.434271,14.292514
19.455589,11.840085,14.384992
19.485982,12.247443,14.469046
19.513629,12.651368,14.568322
19.520596,13.053133,14.680921
19.536311,13.460527,14.762909
19.530703,13.869928,14.850209
19.530831,14.281455,14.932680
19.565655,14.695088,14.987009
19.625780,15.111297,15.005571
19.634081,15.527377,15.026493
19.598905,15.943263,15.051593
19.579980,16.359831,15.053295
19.562340,16.773085,15.030891
19.365938,17.172842,15.077025
19.056451,17.588509,15.148259
18.926771,17.999864,15.087161
18.910060,18.394663,14.952714
18.877144,18.797907,14.854293
18.926900,19.212333,14.789787
19.036571,19.629710,14.764670
19.143740,20.038561,14.788565
19.221863,20.440108,14.830037
19.246099,20.850074,14.847050
19.231829,21.278549,14.825769
19.211833,21.704762,14.825383
19.249319,22.090832,14.905743
19.369738,22.420998,15.075304
19.559478,22.694193,15.289916
19.788809,22.933184,15.482574
19.995086,23.213599,15.614192
20.125984,23.574357,15.677626
20.175523,23.988398,15.680539
20.181858,24.411993,15.633993
20.177380,24.817878,15.550787
20.161421,25.213807,15.447018
20.121948,25.614913,15.340229
20.069743,26.023432,15.234922
20.028778,26.432497,15.132076
20.007471,26.837993,15.034576
19.994015,27.240828,14.936599
19.976729,27.642692,14.829428
19.952973,28.045752,14.719157
19.923868,28.452224,14.621783
19.893763,28.862320,14.543100
19.869298,29.271768,14.464207
19.849186,29.676096,14.364897
19.823627,30.074823,14.244134
19.784900,30.470308,14.113806
19.740198,30.864200,13.980084
19.706712,31.258763,13.843919
19.683158,31.658041,13.714075
19.664435,32.060208,13.589093
19.653290,32.457868,13.455488
19.635875,32.851328,13.320122
19.613880,33.243620,13.194835
19.597393,33.636239,13.087556
19.596333,34.030888,13.002966
19.618842,34.434281,12.956114
19.659152,34.853845,12.963405
19.694288,35.282155,12.998104
19.717779,35.705791,13.018723
19.743233,36.119188,13.010238
19.761262,36.530956,12.994532
19.774944,36.947557,12.991373
19.793881,37.367483,12.999387
19.802126,37.787053,13.005612
19.803952,38.203993,13.003299
19.800277,38.620252,12.998006
19.794592,39.038397,12.997826
19.792377,39.457923,13.002175
19.764706,39.909433,13.000000
20.235294,0.000000,13.000000
20.231790,0.417328,13.000267
20.231447,0.835022,12.999704
20.230063,1.252441,12.999966
20.220588,1.669744,13.000403
20.223751,2.087187,13.000177
20.195886,2.505221,12.999619
20.160546,2.923438,12.999565
20.083084,3.341395,13.000321
20.015219,3.759907,12.999731
19.935836,4.179915,12.998259
19.837578,4.597701,13.001898
19.764915,5.010731,13.009489
19.692558,5.425100,13.009996
19.614425,5.846412,12.993548
19.548213,6.275387,12.962607
19.483742,6.705310,12.940374
19.440246,7.127042,12.946202
19.447811,7.537626,12.975624
19.483760,7.944561,13.008817
19.517602,8.349356,13.055470
19.558728,8.751968,13.117129
19.615681,9.155017,13.178912
19.676367,9.558207,13.240120
19.725446,9.960585,13.308422
19.746238,10.357883,13.402985
19.735566,10.745979,13.544951
19.745201,11.138073,13.680033
19.782380,11.536821,13.782926
19.826056,11.934656,13.886329
19.869000,12.330746,13.998026
19.905797,12.723891,14.125165
19.935478,13.115718,14.260515
19.974647,13.513221,14.368703
19.991540,13.912926,14.482058
20.009303,14.317166,14.583426
20.051806,14.727202,14.649223
20.110302,15.141909,14.676107
20.123453,15.556810,14.706043
20.097058,15.972493,14.737967
20.080040,16.391557,14.743867
20.065128,16.810340,14.729212
19.898788,17.208074,14.779420
19.633260,17.588203,14.842153
19.523940,17.981501,14.789811
19.511895,18.378962,14.675237
19.483051,18.781749,14.581407
19.517982,19.199894,14.506348
19.606770,19.623776,14.470905
19.692912,20.040904,14.479622
19.742020,20.458422,14.492579
19.742011,20.883595,14.483891
19.725884,21.309829,14.460074
19.723467,21.716401,14.477616
19.773112,22.081512,14.580593
19.892197,22.386814,14.761042
20.072308,22.632505,14.975045
20.289603,22.872760,15.165425
20.484391,23.174769,15.301828
20.607521,23.548274,15.368090
20.654034,23.961376,15.371637
20.656910,24.379858,15.323433
20.642764,24.779935,15.234796
20.613453,25.165750,15.124483
20.562739,25.553365,15.014858
20.505977,25.951527,14.910782
20.464858,26.356705,14.811802
20.445499,26.763524,14.722068
20.435312,27.168957,14.633526
20.421029,27.571662,14.532783
20.397873,27.973406,14.423922
20.365891,28.377671,14.324555
20.329690,28.785336,14.241473
20.298916,29.192063,14.156944
20.275724,29.593841,14.054593
20.250418,29.990687,13.936088
20.212808,30.384522,13.811540
20.167528,30.776082,13.682109
20.132978,31.168290,13.545734
20.108061,31.565849,13.414196
20.086477,31.967638,13.294953
20.077387,32.368577,13.183333
20.073755,32.770571,13.089271
20.073072,33.177110,13.023861
20.085562,33.589502,12.993052
20.108860,34.006966,12.990963
20.131802,34.426571,13.001466
20.156624,34.844323,13.006128
20.179620,35.259273,13.000775
20.199814,35.673866,12.994399
20.222722,36.090684,12.996156
20.236687,36.509178,13.002416
20.246361,36.926414,13.004073
20.262167,37.341678,13.000259
20.269661,37.757672,12.996704
20.270734,38.175562,12.998023
20.266917,38.594303,13.001072
20.261871,39.012267,13.001163
20.259988,39.429287,12.998890
20.235294,39.909433,13.000000
20.705882,0.000000,13.000000
20.702868,0.415760,13.000290
20.702560,0.831921,12.999688
20.701361,1.247828,12.999922
20.693196,1.663614,13.000449
20.695876,2.079439,13.000278
20.671946,2.496364,12.999593
20.641895,2.914153,12.999113
20.575192,3.332242,13.000636
20.516868,3.748175,13.003756
20.451505,4.165689,13.002934
20.368852,4.588060,12.996912
20.302164,5.010843,12.993334
20.235324,5.430270,12.996857
20.172054,5.846826,13.003968
20.127017,6.263048,13.007904
20.084670,6.681298,13.004681
20.053408,7.101518,12.996780
20.048852,7.521551,12.990412
20.056225,7.941034,12.986487
20.072135,8.359803,12.984126
20.083770,8.778123,12.981911
20.098202,9.195465,12.982513
20.132150,9.609921,12.995083
20.163953,10.020995,13.024851
20.164752,10.428238,13.076149
20.128738,10.828734,13.158863
20.119332,11.226473,13.249361
20.155781,11.624232,13.333962
20.205817,12.017552,13.434111
20.252585,12.406896,13.552212
20.292011,12.794966,13.678620
20.329560,13.183378,13.809443
20.376519,13.575778,13.922300
20.405283,13.968692,14.045025
20.434892,14.365482,14.154667
20.482615,14.768364,14.228316
20.540231,15.175316,14.268347
20.560958,15.583954,14.316540
20.547623,15.996810,14.364327
20.538063,16.415223,14.382386
20.529992,16.836212,14.380170
20.399577,17.248803,14.442815
20.182140,17.637697,14.515343
20.090463,18.027669,14.470632
20.081306,18.431305,14.367290
20.056740,18.841434,14.280789
20.075043,19.256080,14.198556
20.133791,19.666385,14.142514
20.186943,20.075149,14.112605
20.204683,20.498793,14.080690
20.188257,20.936161,14.048555
20.179231,21.364075,14.037984
20.202320,21.754457,14.090656
20.274917,22.085668,14.226277
20.405622,22.346887,14.433263
20.584037,22.573372,14.669643
20.788966,22.838445,14.861380
20.960274,23.177866,14.975202
21.062463,23.572905,15.022728
21.100260,23.990017,15.018283
21.097698,24.401151,14.962820
21.071474,24.787106,14.860472
21.024740,25.153004,14.735571
20.957028,25.516417,14.617487
20.887707,25.891584,14.508714
20.836672,26.280486,14.402939
20.808185,26.679479,14.303806
20.792829,27.082483,14.207854
20.780735,27.484307,14.105927
20.764830,27.884655,14.001455
20.739174,28.287199,13.909258
20.704228,28.693505,13.833705
20.672481,29.099783,13.756572
20.651367,29.502416,13.663509
20.634204,29.902021,13.560090
20.610291,30.301202,13.460111
20.579605,30.700219,13.364970
20.556219,31.099243,13.267235
20.542011,31.501086,13.173972
20.530974,31.905976,13.093517
20.529546,32.312462,13.027305
20.536631,32.722695,12.983719
20.548084,33.138167,12.966862
20.570277,33.558650,12.976704
20.597101,33.982030,13.002937
20.613921,34.403356,13.024162
20.627676,34.817303,13.020343
20.642648,35.226724,13.001069
20.658531,35.638316,12.988764
20.676645,36.055176,12.993654
20.686655,36.473697,13.003644
20.693129,36.889685,13.005731
20.705044,37.303062,13.000343
20.710235,37.717342,12.995963
20.709962,38.133896,12.997605
20.705641,38.551427,13.001377
20.700423,38.967946,13.001517
20.697858,39.383275,12.998510
20.705882,39.909433,13.000000
21.176471,0.000000,13.000000
21.173973,0.413189,12.999911
21.173698,0.826272,13.000097
21.172638,1.239460,13.000008
21.165826,1.652872,12.999874
21.167972,2.066005,12.999952
21.147960,2.479939,13.000117
21.122395,2.894418,13.000092
21.067148,3.310952,12.999958
21.018523,3.727263,13.000512
20.962879,4.144136,13.000930
20.894122,4.563718,12.998761
20.839272,4.984761,12.995375
20.782937,5.405552,12.995661
20.729733,5.823714,13.003591
20.695267,6.237603,13.018160
20.667589,6.650743,13.029402
20.648245,7.066727,13.028708
20.642496,7.486031,13.017508
20.642481,7.906122,13.004628
20.652683,8.325613,12.989937
20.653782,8.745423,12.972249
20.655607,9.163788,12.957191
20.681957,9.577946,12.952972
20.702880,9.990918,12.957917
20.685786,10.406716,12.968752
20.629383,10.824032,12.989544
20.603832,11.234579,13.022704
20.621973,11.640708,13.063410
20.642505,12.044742,13.118445
20.670842,12.442522,13.191619
20.704370,12.836526,13.272709
20.729812,13.230950,13.361094
20.759987,13.625958,13.446562
20.781632,14.018283,13.550995
20.814139,14.409374,13.654362
20.867285,14.800805,13.739534
20.928587,15.193637,13.805447
20.957951,15.592019,13.876606
20.957997,15.998936,13.941415
20.960044,16.411702,13.974760
20.960316,16.827242,13.983927
20.860418,17.247470,14.048940
20.688313,17.659484,14.124540
20.610898,18.060344,14.082798
20.601677,18.466534,13.978686
20.583285,18.878705,13.892271
20.588444,19.287093,13.805425
20.614951,19.688271,13.729812
20.636461,20.093654,13.670068
20.641721,20.514725,13.619542
20.635658,20.945589,13.595138
20.644184,21.364429,13.619004
20.684328,21.740993,13.718254
20.778458,22.048359,13.894854
20.923164,22.294068,14.130179
21.083579,22.541893,14.366015
21.250994,22.851417,14.516579
21.379699,23.229532,14.579909
21.449512,23.644383,14.597552
21.471069,24.065041,14.580651
21.459323,24.466898,14.516975
21.425958,24.837871,14.403951
21.375427,25.187401,14.272972
21.306309,25.532147,14.158993
21.234617,25.886643,14.056899
21.177879,26.257535,13.951906
21.140590,26.645168,13.846518
21.118934,27.042843,13.744644
21.108668,27.442684,13.645087
21.101779,27.841774,13.551486
21.086524,28.242472,13.473716
21.058214,28.646371,13.412691
21.030087,29.051454,13.351291
21.014018,29.455493,13.277279
21.007640,29.859266,13.198139
21.001811,30.265741,13.131507
20.992696,30.675572,13.084081
20.987097,31.085632,13.047222
20.990793,31.495197,13.018894
20.999800,31.905391,13.000184
21.008731,32.317602,12.989830
21.018553,32.732339,12.988114
21.028443,33.148250,12.992431
21.040263,33.564355,12.998225
21.054044,33.980073,13.001895
21.065519,34.394896,13.002252
21.079843,34.809307,13.000498
21.094249,35.223871,12.999791
21.105938,35.638546,13.000447
21.118899,36.053081,13.000606
21.126401,36.466847,12.999726
21.131336,36.880533,12.999312
21.140020,37.294672,12.999906
21.142715,37.708399,13.000621
21.141330,38.121605,13.000393
21.136676,38.534606,12.999825
21.131055,38.947816,12.999807
21.127546,39.361271,13.000166
21.176471,39.909433,13.000000
21.647059,0.000000,13.000000
21.645061,0.409642,12.999800
21.644820,0.819025,13.000214
21.643922,1.228612,13.000042
21.638437,1.638524,12.999697
21.640073,2.048088,12.999834
21.623981,2.458249,13.000286
21.603178,2.868670,13.000539
21.559100,3.281623,12.999593
21.520141,3.696100,12.997844
21.473948,4.111049,12.998369
21.418043,4.525221,13.001801
21.376371,4.938251,13.004130
21.333731,5.353588,13.002499
21.289242,5.771353,12.997680
21.255134,6.189267,12.992508
21.224522,6.606622,12.990700
21.204132,7.021866,12.992601
21.203581,7.434075,12.995816
21.214009,7.844558,12.999532
21.228408,8.253849,13.005166
21.236703,8.663825,13.012492
21.250064,9.073722,13.018097
21.278254,9.481933,13.017975
21.292458,9.892669,13.011482
21.269491,10.309857,13.002792
21.214879,10.733835,12.994607
21.186910,11.154270,12.986976
21.176829,11.573335,12.975265
21.153120,11.994599,12.967689
21.156542,12.405831,12.977902
21.179685,12.809031,13.002121
21.183624,13.213435,13.036488
21.189701,13.614787,13.080887
21.196947,14.011477,13.147012
21.222390,14.402482,13.224464
21.271035,14.787805,13.304557
21.328716,15.171800,13.379097
21.359737,15.564079,13.452877
21.367528,15.966261,13.517802
21.377979,16.372604,13.556000
21.384612,16.780941,13.570647
21.308750,17.201788,13.628334
21.173164,17.627520,13.691385
21.106643,18.038503,13.648003
21.096071,18.441974,13.544659
21.083678,18.846866,13.456835
21.085080,19.251729,13.379165
21.093064,19.657205,13.309732
21.098005,20.067067,13.252451
21.106930,20.480995,13.214546
21.122811,20.893685,13.215286
21.147441,21.297683,13.268724
21.188977,21.671489,13.387770
21.281887,21.989024,13.562986
21.406192,22.270406,13.770005
21.516395,22.573188,13.955983
21.627785,22.927572,14.050211
21.713769,23.325627,14.079871
21.756508,23.745644,14.083416
21.760796,24.164081,14.059952
21.736031,24.556858,13.990975
21.699672,24.920419,13.874284
21.662715,25.270692,13.750526
21.618302,25.620695,13.660281
21.569113,25.976068,13.588765
21.525947,26.342320,13.511219
21.494033,26.723836,13.426589
21.474516,27.117265,13.342764
21.467934,27.516106,13.264435
21.468477,27.916238,13.196275
21.464691,28.317389,13.144312
21.449883,28.719732,13.107349
21.432923,29.123365,13.071921
21.425009,29.528604,13.028895
21.427634,29.936330,12.984303
21.435141,30.348312,12.953472
21.442565,30.764712,12.944653
21.449925,31.181037,12.950718
21.463645,31.595325,12.964428
21.482678,32.008994,12.981344
21.495632,32.423246,12.998284
21.503798,32.837697,13.011863
21.509446,33.250536,13.018241
21.512573,33.661302,13.013042
21.517477,34.070852,12.998787
21.526366,34.481065,12.986680
21.541645,34.895886,12.988294
21.555745,35.313108,12.999180
21.565096,35.728413,13.006539
21.575271,36.140749,13.003890
21.581651,36.550765,12.997930
21.586063,36.961634,12.996525
21.593240,37.374664,12.999735
21.595200,37.786031,13.002464
21.593925,38.195303,13.001491
21.589903,38.603518,12.999181
21.584923,39.012309,12.999083
21.581673,39.422183,13.000886
21.647059,39.909433,13.000000
22.117647,0.000000,13.000000
22.116131,0.405817,13.000027
22.115929,0.811676,12.999968
22.115237,1.217519,12.999996
22.111055,1.623454,13.000041
22.112237,2.029276,13.000019
22.100090,2.435693,12.999968
22.084621,2.842458,12.999972
22.051217,3.250464,12.999997
22.021814,3.658893,12.999786
21.987620,4.068287,12.999675
21.945491,4.478426,13.000525
21.913411,4.887674,13.001752
21.881005,5.297782,13.001544
21.847650,5.709522,12.998455
21.821439,6.122141,12.992825
21.796678,6.535178,12.988341
21.779488,6.946381,12.988364
21.779270,7.353896,12.992590
21.788434,7.759584,12.997771
21.799716,8.164455,13.004199
21.806828,8.570062,13.012000
21.817757,8.975715,13.018038
21.837726,9.380296,13.018105
21.847663,9.786783,13.014435
21.832460,10.198073,13.010854
21.794465,10.615073,13.007398
21.774013,11.030435,12.999865
21.761359,11.444880,12.986451
21.735443,11.862514,12.970760
21.736256,12.272730,12.961609
21.749625,12.678363,12.959770
21.736959,13.089266,12.960507
21.731078,13.496440,12.968437
21.728901,13.901153,12.984090
21.734805,14.302587,13.008219
21.756353,14.698641,13.041501
21.790447,15.091306,13.078026
21.809826,15.488585,13.116760
21.815749,15.890733,13.154272
21.825833,16.293770,13.178895
21.834122,16.698338,13.190874
21.777960,17.117196,13.230646
21.677359,17.544869,13.276418
21.629784,17.958571,13.249196
21.622458,18.360447,13.178977
21.614199,18.761979,13.119457
21.624626,19.164162,13.077931
21.641295,19.569304,13.046888
21.650975,19.977585,13.021777
21.662689,20.384746,13.007825
21.679411,20.787986,13.017022
21.699815,21.187551,13.053332
21.727045,21.576587,13.116325
21.779871,21.943050,13.202543
21.836154,22.296131,13.315507
21.888943,22.649900,13.445197
21.963149,23.019753,13.527124
22.026825,23.411954,13.563252
22.054675,23.823931,13.570780
22.048073,24.235995,13.549656
22.015830,24.624322,13.486186
21.981875,24.991620,13.381872
21.963271,25.357961,13.279649
21.950344,25.734075,13.219933
21.934748,26.116223,13.186159
21.919564,26.502087,13.152567
21.908124,26.893704,13.114206
21.901693,27.291297,13.075168
21.901381,27.693298,13.038536
21.905976,28.097925,13.009022
21.911888,28.504448,12.992174
21.915732,28.911920,12.988211
21.917363,29.319353,12.988217
21.919886,29.727043,12.984833
21.926248,30.135878,12.978573
21.936013,30.546393,12.975493
21.946961,30.958305,12.979469
21.955658,31.369684,12.987517
21.964366,31.780325,12.994863
21.974921,32.190795,12.998975
21.982529,32.600117,13.001053
21.988231,33.008719,13.002351
21.993720,33.417037,13.002837
22.000190,33.825390,13.001889
22.008494,34.233957,12.999970
22.016773,34.642413,12.998744
22.027451,35.051683,12.999109
22.037831,35.460795,12.999907
22.046309,35.869113,13.000161
22.055699,36.277387,13.000036
22.061450,36.684769,13.000051
22.065489,37.091695,13.000077
22.072152,37.499011,12.999992
22.074910,37.905477,12.999867
22.074837,38.311471,12.999924
22.072510,38.717105,13.000039
22.069530,39.122619,13.000036
22.067966,39.528372,12.999968
22.117647,39.909433,13.000000
22.588235,0.000000,13.000000
22.587215,0.403027,13.000116
22.587070,0.806211,12.999873
22.586600,1.209289,12.999976
22.583777,1.612316,13.000179
22.584544,2.015379,13.000097
22.576404,2.418800,12.999832
22.566196,2.822507,12.999685
22.543699,3.226337,13.000239
22.523965,3.629559,13.001285
22.501861,4.033466,13.001009
22.473988,4.439372,12.998860
22.451211,4.845900,12.997144
22.428057,5.251790,12.997995
22.406482,5.656531,13.001788
22.392224,6.059930,13.007205
22.380225,6.463431,13.010633
22.371433,6.868006,13.009951
22.368659,7.273337,13.006197
22.368449,7.678837,13.001636
22.372092,8.084237,12.995697
22.372167,8.489923,12.988463
22.372318,8.894894,12.982707
22.381442,9.297918,12.981893
22.388898,9.700546,12.985564
22.382817,10.104885,12.990390
22.360290,10.511086,12.995428
22.348144,10.914844,13.002869
22.348826,11.315590,13.014574
22.347386,11.716764,13.025664
22.357448,12.117838,13.029840
22.363487,12.521438,13.028158
22.348759,12.930045,13.024634
22.344637,13.337637,13.016927
22.340825,13.746818,13.000137
22.329180,14.158750,12.979535
22.322287,14.569775,12.962523
22.330984,14.976040,12.954102
22.336717,15.380547,12.954473
22.336417,15.784382,12.960193
22.340508,16.186853,12.966083
22.345696,16.590161,12.971063
22.304971,17.004358,12.982726
22.237219,17.424351,12.998723
22.214507,17.833153,12.995003
22.215250,18.235713,12.979182
22.210304,18.640155,12.968901
22.231386,19.040153,12.970925
22.264815,19.438031,12.980807
22.285005,19.838728,12.988685
22.291939,20.242100,12.990262
22.291519,20.646796,12.988234
22.295136,21.050714,12.981657
22.303886,21.457236,12.966620
22.310584,21.867201,12.958543
22.308802,22.272002,12.986452
22.324772,22.656493,13.059651
22.371528,23.032254,13.124354
22.413463,23.418079,13.158528
22.429722,23.820285,13.167405
22.422967,24.225736,13.155745
22.400406,24.618718,13.118017
22.380186,25.002340,13.056537
22.376796,25.390771,13.000033
22.384316,25.790607,12.974954
22.392335,26.195685,12.970474
22.398866,26.600169,12.970484
22.404578,27.003097,12.970086
22.409353,27.405912,12.968942
22.413429,27.810111,12.966822
22.418523,28.216151,12.966384
22.427113,28.623957,12.971550
22.439384,29.032818,12.983785
22.450518,29.441051,12.999493
22.457673,29.847828,13.014243
22.463094,30.253327,13.025150
22.469168,30.657608,13.031193
22.476316,31.060704,13.032384
22.481384,31.463570,13.029496
22.483639,31.867027,13.022108
22.485601,32.270662,13.010985
22.488284,32.673279,12.999680
22.492217,33.075592,12.991736
22.497694,33.478904,12.989058
22.506472,33.883491,12.992913
22.516506,34.288753,13.001122
22.523231,34.693300,13.007691
22.529275,35.095334,13.006543
22.535813,35.495812,13.000378
22.542526,35.897008,12.996301
22.550002,36.299832,12.997842
22.554483,36.703477,13.001205
22.557674,37.106385,13.001965
22.562923,37.508164,13.000129
22.565630,37.910538,12.998583
22.566242,38.313929,12.999149
22.565285,38.717835,13.000472
22.563966,39.121426,13.000526
22.563638,39.524481,12.999489
22.588235,39.909433,13.000000
23.058824,0.000000,13.000000
23.058322,0.402285,12.999931
23.058251,0.804476,13.000076
23.058008,1.206734,13.000014
23.056613,1.609043,12.999894
23.056989,2.011305,12.999943
23.052923,2.413464,13.000097
23.047647,2.815538,13.000172
23.036570,3.217806,12.999880
23.026739,3.620399,12.999412
23.015064,4.022784,12.999581
23.000955,4.424589,13.000424
22.990357,4.826268,13.000964
22.979486,5.228352,13.000611
22.968163,5.630890,12.999504
22.959420,6.033674,12.998174
22.951457,6.436381,12.997519
22.946000,6.838747,12.997821
22.945595,7.240770,12.998658
22.947950,7.642633,12.999651
22.951304,8.044410,13.001016
22.953205,8.446193,13.002730
22.956322,8.848062,13.004171
22.963078,9.250059,13.004625
22.966502,9.652352,13.003784
22.960889,10.054929,13.002361
22.947402,10.457792,13.000901
22.940245,10.860706,12.999272
22.936982,11.263859,12.996930
22.930214,11.667078,12.995101
22.931112,12.069808,12.994358
22.935093,12.471911,12.994665
22.931372,12.873581,12.995904
22.930129,13.275294,12.997591
22.928868,13.676757,13.000993
22.927694,14.077871,13.005027
22.931909,14.478578,13.008462
22.942841,14.879100,13.010584
22.947249,15.280740,13.009916
22.944148,15.683599,13.007270
22.942449,16.086476,13.005014
22.941477,16.488975,13.003271
22.916018,16.893402,12.998746
22.877838,17.299811,12.993806
22.868939,17.703429,12.994636
22.874394,18.105474,12.998662
22.873614,18.508284,13.001540
22.882356,18.909758,13.002837
22.894697,19.310738,13.002387
22.901085,19.712343,13.001677
22.904506,20.114055,13.002185
22.907296,20.515746,13.003149
22.912101,20.917464,13.003469
22.916967,21.319239,13.003160
22.919357,21.720752,13.002289
22.920380,22.121967,12.999432
22.926191,22.523394,12.993168
22.935827,22.926330,12.982973
22.940163,23.331137,12.972399
22.941659,23.733780,12.967340
22.945430,24.135049,12.968266
22.952745,24.538649,12.974753
22.958701,24.944621,12.984561
22.961369,25.350451,12.993471
22.965586,25.754797,12.998863
22.971683,26.158145,13.002119
22.977586,26.561102,13.004899
22.982113,26.963858,13.007399
22.985339,27.366407,13.009761
22.987953,27.768559,13.012183
22.990203,28.170040,13.013622
22.991840,28.570567,13.012284
22.992616,28.970342,13.007475
22.992997,29.370341,13.001090
22.993881,29.771061,12.995215
22.995927,30.172294,12.990878
22.998881,30.573861,12.988235
23.002146,30.975731,12.987219
23.005341,31.377716,12.987794
23.009788,31.779454,12.990436
23.015437,32.181030,12.995041
23.019467,32.583194,13.000058
23.022296,32.985561,13.003711
23.024514,33.387436,13.005017
23.026019,33.788591,13.003305
23.027877,34.189252,12.999452
23.030778,34.590231,12.996222
23.035455,34.992218,12.996698
23.039814,35.394993,12.999808
23.042802,35.797558,13.001972
23.045943,36.199156,13.001179
23.048102,36.600598,12.999327
23.049747,37.002589,12.998893
23.052055,37.404948,12.999927
23.052974,37.807356,13.000822
23.053075,38.209458,13.000493
23.052472,38.611499,12.999728
23.051611,39.013797,12.999699
23.051184,39.416257,13.000291
23.058824,39.909433,13.000000
23.529412,0.000000,13.000000
23.529412,0.404017,13.000000
23.529412,0.808033,13.000000
23.529412,1.212050,13.000000
23.529412,1.616066,13.000000
23.529412,2.020083,13.000000
23.529412,2.424099,13.000000
23.529412,2.828116,13.000000
23.529412,3.232132,13.000000
23.529412,3.636149,13.000000
23.529412,4.040165,13.000000
23.529412,4.444182,13.000000
23.529412,4.848198,13.000000
23.529412,5.252215,13.000000
23.529412,5.656232,13.000000
23.529412,6.060248,13.000000
23.529412,6.464265,13.000000
23.529412,6.868281,13.000000
23.529412,7.272298,13.000000
23.529412,7.676314,13.000000
23.529412,8.080331,13.000000
23.529412,8.484347,13.000000
23.529412,8.888364,13.000000
23.529412,9.292380,13.000000
23.529412,9.696397,13.000000
23.529412,10.100414,13.000000
23.529412,10.504430,13.000000
23.529412,10.908447,13.000000
23.529412,11.312463,13.000000
23.529412,11.716480,13.000000
23.529412,12.120496,13.000000
23.529412,12.524513,13.000000
23.529412,12.928529,13.000000
23.529412,13.332546,13.000000
23.529412,13.736562,13.000000
23.529412,14.140579,13.000000
23.529412,14.544595,13.000000
23.529412,14.948612,13.000000
23.529412,15.352629,13.000000
23.529412,15.756645,13.000000
23.529412,16.160662,13.000000
23.529412,16.564678,13.000000
23.529412,16.968695,13.000000
23.529412,17.372711,13.000000
23.529412,17.776728,13.000000
23.529412,18.180744,13.000000
23.529412,18.584761,13.000000
23.529412,18.988777,13.000000
23.529412,19.392794,13.000000
23.529412,19.796810,13.000000
23.529412,20.200827,13.000000
23.529412,20.604844,13.000000
23.529412,21.008860,13.000000
23.529412,21.412877,13.000000
23.529412,21.816893,13.000000
23.529412,22.220910,13.000000
23.529412,22.624926,13.000000
23.529412,23.028943,13.000000
23.529412,23.432959,13.000000
23.529412,23.836976,13.000000
23.529412,24.240992,13.000000
23.529412,24.645009,13.000000
23.529412,25.049025,13.000000
23.529412,25.453042,13.000000
23.529412,25.857059,13.000000
23.529412,26.261075,13.000000
23.529412,26.665092,13.000000
23.529412,27.069108,13.000000
23.529412,27.473125,13.000000
23.529412,27.877141,13.000000
23.529412,28.281158,13.000000
23.529412,28.685174,13.000000
23.529412,29.089191,13.000000
23.529412,29.493207,13.000000
23.529412,29.897224,13.000000
23.529412,30.301241,13.000000
23.529412,30.705257,13.000000
23.529412,31.109274,13.000000
23.529412,31.513290,13.000000
23.529412,31.917307,13.000000
23.529412,32.321323,13.000000
23.529412,32.725340,13.000000
23.529412,33.129356,13.000000
23.529412,33.533373,13.000000
23.529412,33.937389,13.000000
23.529412,34.341406,13.000000
23.529412,34.745422,13.000000
23.529412,35.149439,13.000000
23.529412,35.553456,13.000000
23.529412,35.957472,13.000000
23.529412,36.361489,13.000000
23.529412,36.765505,13.000000
23.529412,37.169522,13.000000
23.529412,37.573538,13.000000
23.529412,37.977555,13.000000
23.529412,38.381571,13.000000
23.529412,38.785588,13.000000
23.529412,39.189604,13.000000
23.529412,39.593621,13.000000
23.529412,39.909433,13.000000
