50,100
0.470588,0.000000,13.000000
0.470588,0.403126,13.000000
0.470588,0.806251,13.000000
0.470588,1.209377,13.000000
0.470588,1.612502,13.000000
0.470588,2.015628,13.000000
0.470588,2.418754,13.000000
0.470588,2.821879,13.000000
0.470588,3.225005,13.000000
0.470588,3.628130,13.000000
0.470588,4.031256,13.000000
0.470588,4.434381,13.000000
0.470588,4.837507,13.000000
0.470588,5.240633,13.000000
0.470588,5.643758,13.000000
0.470588,6.046884,13.000000
0.470588,6.450009,13.000000
0.470588,6.853135,13.000000
0.470588,7.256261,13.000000
0.470588,7.659386,13.000000
0.470588,8.062512,13.000000
0.470588,8.465637,13.000000
0.470588,8.868763,13.000000
0.470588,9.271888,13.000000
0.470588,9.675014,13.000000
0.470588,10.078140,13.000000
0.470588,10.481265,13.000000
0.470588,10.884391,13.000000
0.470588,11.287516,13.000000
0.470588,11.690642,13.000000
0.470588,12.093768,13.000000
0.470588,12.496893,13.000000
0.470588,12.900019,13.000000
0.470588,13.303144,13.000000
0.470588,13.706270,13.000000
0.470588,14.109395,13.000000
0.470588,14.512521,13.000000
0.470588,14.915647,13.000000
0.470588,15.318772,13.000000
0.470588,15.721898,13.000000
0.470588,16.125023,13.000000
0.470588,16.528149,13.000000
0.470588,16.931275,13.000000
0.470588,17.334400,13.000000
0.470588,17.737526,13.000000
0.470588,18.140651,13.000000
0.470588,18.543777,13.000000
0.470588,18.946902,13.000000
0.470588,19.350028,13.000000
0.470588,19.753154,13.000000
0.470588,20.156279,13.000000
0.470588,20.559405,13.000000
0.470588,20.962530,13.000000
0.470588,21.365656,13.000000
0.470588,21.768782,13.000000
0.470588,22.171907,13.000000
0.470588,22.575033,13.000000
0.470588,22.978158,13.000000
0.470588,23.381284,13.000000
0.470588,23.784409,13.000000
0.470588,24.187535,13.000000
0.470588,24.590661,13.000000
0.470588,24.993786,13.000000
0.470588,25.396912,13.000000
0.470588,25.800037,13.000000
0.470588,26.203163,13.000000
0.470588,26.606289,13.000000
0.470588,27.009414,13.000000
0.470588,27.412540,13.000000
0.470588,27.815665,13.000000
0.470588,28.218791,13.000000
0.470588,28.621917,13.000000
0.470588,29.025042,13.000000
0.470588,29.428168,13.000000
0.470588,29.831293,13.000000
0.470588,30.234419,13.000000
0.470588,30.637544,13.000000
0.470588,31.040670,13.000000
0.470588,31.443796,13.000000
0.470588,31.846921,13.000000
0.470588,32.250047,13.000000
0.470588,32.653172,13.000000
0.470588,33.056298,13.000000
0.470588,33.459424,13.000000
0.470588,33.862549,13.000000
0.470588,34.265675,13.000000
0.470588,34.668800,13.000000
0.470588,35.071926,13.000000
0.470588,35.475051,13.000000
0.470588,35.878177,13.000000
0.470588,36.281303,13.000000
0.470588,36.684428,13.000000
0.470588,37.087554,13.000000
0.470588,37.490679,13.000000
0.470588,37.893805,13.000000
0.470588,38.296931,13.000000
0.470588,38.700056,13.000000
0.470588,39.103182,13.000000
0.470588,39.506307,13.000000
0.470588,39.909433,13.000000
0.941176,0.000000,13.000000
0.941682,0.402384,13.000037
0.941748,0.804859,12.999940
0.941983,1.207201,13.000029
0.943382,1.609513,13.000075
0.942987,2.011997,12.999969
0.947050,2.414201,12.999883
0.952282,2.816118,12.999973
0.963512,3.217416,13.000037
0.973454,3.618730,12.999965
0.985004,4.019489,13.000214
0.999084,4.419499,13.000663
1.010125,4.820214,13.000033
1.022167,5.221468,12.998356
1.034667,5.622505,12.997333
1.043523,6.022968,12.998297
1.050119,6.422704,13.000657
1.054055,6.822211,13.003744
1.053941,7.222431,13.006300
1.051736,7.623548,13.007276
1.048818,8.025497,13.006393
1.048743,8.427537,13.004434
1.048440,8.830057,13.001524
1.043909,9.233674,12.997611
1.042089,9.636674,12.993668
1.049518,10.037426,12.989757
1.066174,10.435765,12.986165
1.075477,10.834894,12.985621
1.077047,11.234968,12.987717
1.079981,11.634302,12.990952
1.076604,12.034826,12.996811
1.071367,12.434358,13.005250
1.072171,12.830482,13.014092
1.069570,13.228988,13.019881
1.070168,13.629551,13.022744
1.074140,14.031066,13.023496
1.073246,14.434382,13.020329
1.064904,14.840120,13.012569
1.062267,15.244465,13.004494
1.066687,15.647085,12.997729
1.069540,16.050277,12.993110
1.071049,16.452988,12.990664
1.097969,16.847102,12.987544
1.137345,17.237498,12.987311
1.144382,17.634166,12.996629
1.136550,18.035376,13.011922
1.136433,18.437198,13.024986
1.127580,18.840409,13.028300
1.115139,19.243232,13.025650
1.109396,19.644710,13.023229
1.108392,20.047193,13.021185
1.109545,20.452227,13.018296
1.106473,20.859516,13.012939
1.100211,21.267020,13.001830
1.100054,21.676594,12.981987
1.108170,22.088572,12.961645
1.107807,22.496521,12.956069
1.091157,22.902149,12.963246
1.076919,23.308761,12.969285
1.071603,23.713655,12.971191
1.069563,24.116002,12.971695
1.066721,24.517310,12.972697
1.063591,24.918782,12.974543
1.060284,25.321568,12.977007
1.053568,25.726094,12.980963
1.044956,26.130893,12.985962
1.036415,26.535146,12.991789
1.029299,26.938626,12.998190
1.024381,27.341499,13.004427
1.021284,27.744099,13.009680
1.018980,28.146552,13.013273
1.016561,28.548764,13.014719
1.013763,28.950692,13.014268
1.011551,29.352433,13.013161
1.010627,29.754056,13.011876
1.010244,30.155730,13.010049
1.009449,30.557628,13.007406
1.007736,30.959783,13.004112
1.005717,31.361926,13.001002
1.003264,31.764174,12.998853
1.000316,32.166790,12.998053
0.997898,32.569544,12.998168
0.995355,32.972657,12.999011
0.992674,33.375940,13.000103
0.989800,33.779205,13.000818
0.986643,34.182486,13.000933
0.983847,34.585587,13.000673
0.980187,34.989002,13.000265
0.976447,35.392515,13.000036
0.973315,35.795875,13.000006
0.969853,36.199426,13.000006
0.967710,36.602498,12.999944
0.966187,37.005361,12.999909
0.963702,37.408672,12.999959
0.962662,37.811409,13.000036
0.962664,38.213687,13.000023
0.963504,38.615586,12.999976
0.964601,39.017371,12.999982
0.965181,39.419385,13.000019
0.941176,39.909433,13.000000
1.411765,0.000000,13.000000
1.412793,0.400725,12.999827
1.412996,0.801018,13.000278
1.413551,1.201905,12.999866
1.416471,1.602725,12.999631
1.415887,2.002973,13.000151
1.424255,2.403377,13.000663
1.434638,2.804541,13.000197
1.457034,3.206826,12.999138
1.477305,3.608544,12.999373
1.500234,4.009477,13.001086
1.527951,4.411750,13.001522
1.549900,4.815345,13.000047
1.572935,5.219653,12.998574
1.595580,5.623637,12.998664
1.611810,6.026880,12.999519
1.626110,6.430178,13.000160
1.636342,6.833341,13.000279
1.637915,7.235458,13.000308
1.634884,7.636835,13.000504
1.629336,8.037742,13.000714
1.627162,8.439199,13.000540
1.623625,8.840411,13.000091
1.612826,9.240377,12.998873
1.607127,9.641184,12.996938
1.616946,10.044482,12.996506
1.640790,10.450857,12.999167
1.653233,10.855497,13.001265
1.657332,11.258402,13.002059
1.666716,11.662903,13.002723
1.662896,12.063838,13.002220
1.656576,12.463482,13.002472
1.667120,12.868044,13.002111
1.670711,13.271214,12.999639
1.674319,13.675198,12.994003
1.681030,14.079925,12.988228
1.679678,14.481195,12.986428
1.664520,14.877331,12.988298
1.657602,15.276285,12.989333
1.661103,15.678639,12.990674
1.661120,16.079782,12.992297
1.660044,16.480826,12.993512
1.702274,16.898867,13.001323
1.768973,17.330869,13.011189
1.790885,17.745137,13.003202
1.788106,18.146080,12.986721
1.791953,18.548811,12.975099
1.774814,18.944428,12.975940
1.749185,19.338674,12.981011
1.734825,19.737635,12.982357
1.727522,20.137005,12.983698
1.722700,20.534050,12.989203
1.715761,20.930035,12.994775
1.709284,21.329855,12.993595
1.703584,21.730305,12.988987
1.700953,22.124688,12.997938
1.691093,22.504808,13.039784
1.656676,22.872553,13.087156
1.616942,23.250227,13.114693
1.597483,23.648650,13.125790
1.596602,24.054042,13.124249
1.607489,24.453129,13.105550
1.622353,24.842844,13.063143
1.627085,25.231597,13.009229
1.617675,25.629619,12.975767
1.604381,26.034998,12.967515
1.592724,26.442553,12.973606
1.583978,26.849300,12.984150
1.577735,27.254326,12.993135
1.572629,27.657547,12.997670
1.567273,28.060010,13.000145
1.560431,28.462704,13.003529
1.552110,28.865878,13.008918
1.545486,29.268774,13.015155
1.542464,29.670680,13.018960
1.540860,30.071961,13.018325
1.538640,30.473208,13.014818
1.535163,30.874519,13.010185
1.531634,31.275359,13.004954
1.527682,31.675494,12.999918
1.523317,32.075344,12.996115
1.519754,32.475907,12.994397
1.514940,32.878210,12.996156
1.509330,33.281462,13.000452
1.503582,33.684223,13.004573
1.498014,34.086187,13.006758
1.494123,34.487209,13.006555
1.488970,34.887781,13.004310
1.483459,35.288367,13.001425
1.478608,35.688905,12.999614
1.473278,36.089702,12.999893
1.470507,36.490528,13.001023
1.468776,36.891134,13.001325
1.465399,37.291568,13.000467
1.464558,37.691975,12.999634
1.465544,38.092578,12.999765
1.468001,38.493258,13.000267
1.470873,38.893821,13.000215
1.472852,39.294305,12.999766
1.411765,39.909433,13.000000
1.882353,0.000000,13.000000
1.883858,0.404343,13.000209
1.884018,0.809214,12.999664
1.884669,1.213392,13.000163
1.888776,1.617860,13.000458
1.887473,2.022775,12.999813
1.899398,2.428657,12.999128
1.914943,2.834288,12.999720
1.948243,3.240910,13.001463
1.976557,3.648950,13.001234
2.010021,4.061080,12.997419
2.052679,4.474620,12.995404
2.084845,4.883831,12.999837
2.114119,5.291399,13.006982
2.142606,5.701287,13.009364
2.165337,6.113418,13.005209
2.189598,6.527512,12.998057
2.207890,6.941486,12.990185
2.211509,7.352581,12.983681
2.207760,7.760980,12.980653
2.199039,8.166936,12.982372
2.191184,8.572715,12.987866
2.178992,8.976842,12.996331
2.156261,9.376753,13.008639
2.139583,9.778633,13.022383
2.144520,10.189464,13.033318
2.172684,10.609894,13.037429
2.187472,11.026310,13.034737
2.196326,11.438789,13.026996
2.218767,11.854363,13.014641
2.215357,12.264265,12.998537
2.205874,12.675894,12.977102
2.229692,13.097738,12.958512
2.244240,13.511705,12.951625
2.247592,13.918993,12.953858
2.242503,14.322349,12.963425
2.227595,14.720017,12.986204
2.201411,15.110557,13.025952
2.184756,15.504972,13.074916
2.176899,15.904955,13.120974
2.164241,16.304282,13.151329
2.153866,16.706273,13.166591
2.206391,17.136682,13.200857
2.302203,17.579276,13.235162
2.347523,17.996831,13.195680
2.356482,18.398915,13.112803
2.366927,18.802443,13.049143
2.352358,19.203325,13.014722
2.325589,19.605403,12.996561
2.307042,20.012505,12.981720
2.291128,20.418483,12.973446
2.273390,20.817119,12.984983
2.254783,21.205517,13.022346
2.239841,21.584947,13.092735
2.202353,21.944921,13.200351
2.133468,22.282415,13.334518
2.066118,22.615651,13.475211
2.007682,22.952585,13.562485
1.956801,23.308012,13.591965
1.926034,23.699466,13.600886
1.919948,24.110717,13.594382
1.938800,24.512898,13.553934
1.972419,24.891549,13.463983
2.000875,25.256874,13.345261
2.023568,25.628107,13.249747
2.050443,26.010137,13.187863
2.081017,26.400390,13.141944
2.107292,26.797255,13.098543
2.123095,27.197934,13.052998
2.127877,27.599268,13.006223
2.125874,28.001450,12.967538
2.121623,28.406543,12.945849
2.118804,28.814924,12.940794
2.116399,29.224170,12.940904
2.108995,29.633253,12.940647
2.094460,30.042665,12.942839
2.075453,30.452553,12.951717
2.056901,30.862643,12.968949
2.044217,31.272637,12.989536
2.033710,31.682630,13.006125
2.020416,32.091998,13.014365
2.010936,32.498709,13.015541
2.007458,32.900915,13.009323
2.005449,33.300978,12.998703
2.000103,33.702248,12.989505
1.990294,34.105205,12.985107
1.978788,34.509993,12.985983
1.965374,34.915269,12.991181
1.953385,35.320083,12.997220
1.944383,35.724735,13.000730
1.934615,36.128510,13.000216
1.928114,36.532377,12.998271
1.923437,36.936651,12.997786
1.916478,37.340681,12.999241
1.913203,37.745162,13.000584
1.912482,38.149729,13.000380
1.913721,38.554584,12.999571
1.915535,38.959818,12.999646
1.916092,39.364942,13.000388
1.882353,39.909433,13.000000
2.352941,0.000000,13.000000
2.354913,0.409751,13.000167
2.355030,0.819927,12.999732
2.355724,1.229553,13.000130
2.360961,1.639495,13.000348
2.358936,2.049670,12.999855
2.374530,2.460927,12.999410
2.394660,2.872247,12.999845
2.438362,3.285594,13.000485
2.476404,3.699898,13.000179
2.520622,4.115436,13.000103
2.574831,4.531722,13.001239
2.616366,4.948504,13.000117
2.660357,5.368026,12.995821
2.705456,5.788287,12.992643
2.736882,6.205486,12.994980
2.760639,6.620461,13.001616
2.774122,7.033191,13.010684
2.771100,7.444012,13.018148
2.759560,7.855103,13.020790
2.744742,8.266942,13.018297
2.739297,8.680331,13.013349
2.731938,9.093719,13.006117
2.708745,9.504844,12.996287
2.695611,9.916973,12.986115
2.716349,10.334646,12.974637
2.770756,10.757650,12.962537
2.798678,11.174906,12.959650
2.801697,11.589084,12.963532
2.812579,12.006279,12.968376
2.798537,12.415986,12.981268
2.771145,12.819017,13.007456
2.763773,13.224823,13.047105
2.751612,13.627304,13.098745
2.739989,14.026841,13.161100
2.716219,14.424584,13.222218
2.677078,14.820509,13.278843
2.633117,15.215029,13.335543
2.610044,15.613399,13.404024
2.603441,16.017443,13.469439
2.593919,16.424433,13.507478
2.587288,16.833901,13.522005
2.659413,17.254824,13.581221
2.787431,17.674201,13.649901
2.846365,18.078068,13.607894
2.853829,18.479643,13.504224
2.867590,18.887510,13.424020
2.862800,19.294973,13.353732
2.845963,19.696500,13.290376
2.834676,20.099285,13.238446
2.824748,20.514107,13.199887
2.812220,20.939137,13.194426
2.785604,21.351156,13.247050
2.744979,21.722637,13.379081
2.670882,22.044514,13.564477
2.554949,22.341516,13.751633
2.441757,22.648447,13.935688
2.340294,22.982789,14.064938
2.259677,23.346314,14.123879
2.212906,23.744380,14.145766
2.202917,24.161270,14.136698
2.229954,24.562754,14.076017
2.279152,24.930930,13.953716
2.327049,25.280779,13.799095
2.376666,25.634356,13.666650
2.433946,26.000614,13.570137
2.490725,26.380211,13.492861
2.534427,26.771978,13.420440
2.559815,27.170996,13.346244
2.569815,27.572109,13.270968
2.573374,27.974117,13.205269
2.579510,28.378004,13.157647
2.592352,28.783488,13.123427
2.602921,29.189421,13.087051
2.603489,29.596226,13.049625
2.598728,30.003865,13.022051
2.591962,30.412342,13.004641
2.582985,30.822291,12.994251
2.573171,31.233865,12.988866
2.560182,31.646885,12.987966
2.544025,32.060437,12.990596
2.531476,32.473705,12.994554
2.520929,32.886431,12.997707
2.510396,33.298417,12.999109
2.498589,33.710052,12.998882
2.484867,34.121273,12.997400
2.471558,34.532369,12.996231
2.454894,34.943591,12.996761
2.438385,35.354673,12.998885
2.424643,35.765535,13.000671
2.409769,36.175753,13.000404
2.399673,36.585736,12.999037
2.391902,36.995845,12.998535
2.380703,37.405783,12.999461
2.374692,37.815931,13.000481
2.372322,38.226063,13.000324
2.372787,38.636368,12.999675
2.374038,39.046956,12.999722
2.373398,39.457466,13.000300
2.352941,39.909433,13.000000
2.823529,0.000000,13.000000
2.825980,0.414402,12.999636
2.826123,0.827898,13.000585
2.826912,1.242643,12.999718
2.833373,1.657363,12.999200
2.830823,2.070700,13.000322
2.850416,2.484800,13.001529
2.874828,2.900810,13.000501
2.928915,3.320539,12.997402
2.977872,3.738562,12.997800
3.033078,4.152413,13.004475
3.098908,4.568326,13.007700
3.150896,4.990292,13.000280
3.208748,5.415795,12.989646
3.266144,5.837943,12.987592
3.304194,6.254931,12.994341
3.333250,6.669725,13.003466
3.351339,7.084120,13.011175
3.349366,7.498634,13.016350
3.336343,7.913666,13.018421
3.317422,8.329686,13.015288
3.310848,8.747258,13.007863
3.303232,9.165506,12.997754
3.275735,9.583576,12.982622
3.260808,10.001681,12.964139
3.286809,10.418804,12.952716
3.348026,10.833124,12.963794
3.374762,11.242932,12.992853
3.365159,11.652381,13.027894
3.352577,12.063601,13.068796
3.322646,12.469158,13.118641
3.281136,12.861155,13.198956
3.240766,13.246090,13.305813
3.198353,13.632800,13.419001
3.172789,14.023141,13.542393
3.136090,14.416342,13.653539
3.076274,14.811529,13.739497
3.014216,15.210473,13.801243
2.988597,15.614384,13.867620
2.993128,16.024788,13.928600
2.996820,16.440921,13.956899
3.001620,16.857658,13.959986
3.102245,17.268896,14.025226
3.269499,17.668829,14.102542
3.340214,18.065474,14.059427
3.345476,18.469372,13.952573
3.365485,18.879967,13.865719
3.359462,19.290377,13.779169
3.333547,19.691833,13.699092
3.317915,20.091508,13.635395
3.313014,20.510942,13.584177
3.313110,20.952703,13.561617
3.296579,21.382103,13.597259
3.253800,21.753850,13.727767
3.166179,22.056748,13.935087
3.023070,22.327329,14.142474
2.877423,22.610129,14.332240
2.732934,22.936775,14.481797
2.615981,23.310030,14.570514
2.555956,23.717101,14.608647
2.548398,24.135436,14.598703
2.578693,24.535970,14.532620
2.626331,24.906226,14.414608
2.673271,25.261634,14.269415
2.726917,25.619041,14.138519
2.789788,25.987138,14.037281
2.849138,26.368209,13.954985
2.891744,26.761249,13.879157
2.915778,27.161113,13.800971
2.927517,27.562825,13.719110
2.938192,27.964197,13.641701
2.957982,28.364367,13.573382
2.987753,28.762478,13.505726
3.011423,29.159953,13.424329
3.025704,29.558616,13.338421
3.045021,29.957620,13.265732
3.068628,30.357147,13.200195
3.084886,30.758806,13.131653
3.087803,31.163196,13.064444
3.079964,31.569929,13.012615
3.070774,31.978751,12.984822
3.061613,32.392691,12.975173
3.044127,32.815244,12.981487
3.023048,33.241559,12.997669
3.003131,33.665943,13.013401
2.985734,34.087212,13.021878
2.973806,34.504668,13.021587
2.957979,34.920639,13.013908
2.940064,35.336569,13.004674
2.923120,35.752091,12.999348
2.904764,36.168259,13.000038
2.892914,36.584029,13.002710
2.883525,36.999018,13.003239
2.869588,37.413627,13.001104
2.862106,37.827940,12.999243
2.859272,38.242554,12.999526
2.860161,38.657250,13.000600
2.861991,39.071635,13.000470
2.861316,39.485834,12.999482
2.823529,39.909433,13.000000
3.294118,0.000000,13.000000
3.297062,0.416923,12.999645
3.297239,0.832959,13.000568
3.298207,1.250205,12.999728
3.305989,1.667316,12.999262
3.302946,2.083249,13.000300
3.326455,2.499622,13.001242
3.356051,2.917431,13.000337
3.421570,3.336558,12.999080
3.479377,3.754217,12.999752
3.545801,4.172539,12.999232
3.629219,4.593442,12.996049
3.693743,5.010659,12.999688
3.754080,5.422206,13.011548
3.810559,5.833518,13.019593
3.854557,6.250404,13.013386
3.904029,6.672685,12.996898
3.943441,7.098381,12.974831
3.952877,7.523610,12.955645
3.946911,7.945029,12.947121
3.928641,8.362219,12.950742
3.910043,8.776747,12.963786
3.884831,9.189300,12.985907
3.839801,9.599930,13.016350
3.801616,10.009370,13.051961
3.797941,10.415742,13.103696
3.827897,10.816536,13.189876
3.832430,11.216969,13.278126
3.810806,11.619396,13.352314
3.781318,12.022188,13.424910
3.734380,12.425027,13.495073
3.687363,12.818034,13.596892
3.644732,13.202016,13.726812
3.600629,13.588929,13.849448
3.577807,13.979799,13.982559
3.544975,14.375256,14.102358
3.483972,14.773935,14.193156
3.414817,15.176717,14.253039
3.391701,15.584836,14.309701
3.409700,15.999713,14.355641
3.424914,16.419714,14.368516
3.438064,16.838827,14.358871
3.569801,17.244023,14.412165
3.778537,17.632547,14.480841
3.861872,18.030282,14.434799
3.871380,18.437190,14.320942
3.900546,18.843037,14.225999
3.877225,19.254382,14.143983
3.814070,19.668463,14.086209
3.770810,20.080494,14.052466
3.757485,20.500572,14.025076
3.765584,20.929726,14.001984
3.778497,21.348404,13.990843
3.778230,21.726628,14.037917
3.722857,22.048029,14.194079
3.567763,22.319170,14.435551
3.375484,22.578266,14.666262
3.185739,22.876669,14.841074
3.030383,23.239141,14.953735
2.954857,23.645486,15.005787
2.948057,24.063241,14.998896
2.974035,24.467824,14.940526
3.008047,24.849745,14.845020
3.041918,25.220698,14.726039
3.087133,25.591570,14.609746
3.144564,25.969392,14.512167
3.198996,26.356568,14.429445
3.236650,26.752282,14.353044
3.258607,27.152497,14.272953
3.274247,27.553359,14.184778
3.294874,27.952722,14.094039
3.327113,28.349755,14.005832
3.365502,28.744793,13.915711
3.392571,29.139820,13.811422
3.413699,29.535194,13.699852
3.449258,29.929659,13.598739
3.492361,30.323672,13.500662
3.524579,30.718189,13.391933
3.538993,31.114241,13.278002
3.542471,31.513128,13.178347
3.546097,31.915768,13.105684
3.545674,32.323608,13.051006
3.536901,32.738366,13.012518
3.525494,33.157157,12.990746
3.508242,33.578463,12.984848
3.485967,34.002553,12.991904
3.466504,34.426390,13.002594
3.444545,34.849070,13.006853
3.422914,35.269925,13.003239
3.404031,35.689424,12.998737
3.383465,36.109930,12.998878
3.370044,36.529640,13.001708
3.359612,36.948299,13.002851
3.344128,37.367040,13.001061
3.335912,37.784549,12.999073
3.332920,38.201812,12.999380
3.334086,38.618694,13.000630
3.336309,39.035074,13.000531
3.335747,39.451575,12.999434
3.294118,39.909433,13.000000
3.764706,0.000000,13.000000
3.768156,0.417023,13.000519
3.768346,0.835348,12.999159
3.769565,1.251904,13.000409
3.778736,1.668752,13.001165
3.775147,2.087263,12.999521
3.802364,2.506120,12.997682
3.838141,2.922921,12.999230
3.915644,3.336564,13.004425
3.980852,3.753069,13.003822
4.058752,4.178522,12.991844
4.159448,4.602126,12.986283
4.234487,5.013592,13.000041
4.302308,5.420365,13.017182
4.371782,5.835095,13.015758
4.428726,6.257792,12.999047
4.485236,6.682308,12.983573
4.526287,7.103828,12.980366
4.525788,7.520799,12.987638
4.504198,7.935929,12.997969
4.476756,8.346941,13.023702
4.441867,8.753609,13.067207
4.396037,9.157655,13.123300
4.335987,9.559047,13.193598
4.277205,9.957404,13.284047
4.241144,10.351809,13.404953
4.237681,10.740659,13.564009
4.220819,11.133420,13.704411
4.190712,11.530095,13.813060
4.152853,11.926559,13.910438
4.092913,12.328493,13.990180
4.045930,12.728412,14.091995
4.020173,13.123332,14.215432
3.992358,13.521885,14.315528
3.983587,13.921219,14.422700
3.966483,14.324969,14.518745
3.921245,14.733946,14.585934
3.860423,15.146095,14.625218
3.845881,15.558921,14.665948
3.873414,15.973708,14.699535
3.892259,16.390667,14.703195
3.906370,16.806760,14.687329
4.062258,17.204539,14.739809
4.307455,17.586984,14.814926
4.405272,17.983077,14.764139
4.420051,18.382501,14.638792
4.454404,18.778076,14.540371
4.413435,19.191364,14.467766
4.314180,19.622261,14.434406
4.238324,20.051617,14.436389
4.207136,20.470527,14.442645
4.213215,20.877718,14.430947
4.249134,21.279058,14.386139
4.290995,21.671309,14.354221
4.283775,22.032577,14.428888
4.150232,22.331646,14.657502
3.922091,22.586954,14.941372
3.693361,22.852729,15.164617
3.501696,23.177266,15.302039
3.399818,23.566231,15.368728
3.381982,23.985092,15.373159
3.396517,24.401327,15.328340
3.414471,24.797232,15.248491
3.433902,25.180426,15.141887
3.469551,25.561931,15.029334
3.523117,25.948265,14.927761
3.577031,26.340563,14.837656
3.614574,26.737745,14.753575
3.638448,27.136936,14.664295
3.660925,27.535396,14.562570
3.691245,27.932496,14.455365
3.728601,28.330077,14.356074
3.761826,28.730321,14.268650
3.779883,29.131873,14.175345
3.797217,29.531212,14.070422
3.835350,29.926923,13.966465
3.883081,30.319671,13.858687
3.920128,30.709744,13.734602
3.941670,31.099536,13.598768
3.956579,31.493113,13.468963
3.972037,31.891995,13.354687
3.980788,32.291323,13.242805
3.990487,32.686948,13.132097
4.002742,33.082523,13.036246
3.998923,33.486432,12.973308
3.977470,33.901517,12.951997
3.947776,34.324358,12.959868
3.913779,34.750620,12.978953
3.884606,35.175241,12.993978
3.862762,35.598042,13.000176
3.838766,36.020172,12.998607
3.822026,36.440629,12.995701
3.809486,36.860938,12.995726
3.791593,37.282779,12.998583
3.782105,37.702584,13.000730
3.778441,38.120542,13.000429
3.779274,38.537330,12.999300
3.781420,38.954217,12.999492
3.780586,39.371996,13.000586
3.764706,39.909433,13.000000
4.235294,0.000000,13.000000
4.239248,0.416798,13.000797
4.239480,0.835603,12.998712
4.240928,1.251683,13.000626
4.251478,1.668269,13.001690
4.247426,2.087286,12.999289
4.278599,2.506438,12.997041
4.319592,2.922786,12.999206
4.407649,3.337645,13.002659
4.483603,3.756235,13.000864
4.572837,4.175024,13.000655
4.680591,4.588137,13.008198
4.762764,5.007910,13.002171
4.857686,5.441309,12.976411
4.959647,5.876099,12.956737
5.025434,6.297901,12.968851
5.055940,6.705161,13.014749
5.066402,7.098528,13.098261
5.030859,7.486174,13.192479
4.965203,7.881443,13.261028
4.911010,8.279300,13.330322
4.858388,8.676302,13.409157
4.795894,9.074558,13.486338
4.726414,9.473907,13.563873
4.663258,9.870440,13.663576
4.622160,10.260489,13.804889
4.616687,10.642835,13.988883
4.599533,11.032274,14.144356
4.567502,11.427996,14.268846
4.529817,11.824363,14.383043
4.467931,12.228229,14.465119
4.427341,12.634065,14.554186
4.423813,13.038599,14.659863
4.412512,13.447560,14.739783
4.417361,13.855190,14.823974
4.415755,14.265695,14.898629
4.384989,14.682812,14.941582
4.332696,15.104268,14.954581
4.325966,15.521444,14.977952
4.358637,15.934747,15.006177
4.376421,16.348860,15.010329
4.388352,16.762406,14.994334
4.565406,17.156798,15.056778
4.852586,17.546196,15.137210
4.971511,17.937144,15.069547
4.987857,18.322134,14.931609
5.023310,18.713030,14.833513
4.971849,19.127295,14.765277
4.855732,19.560274,14.736821
4.761155,19.992191,14.749629
4.710598,20.406030,14.771647
4.702425,20.803469,14.776137
4.733310,21.204813,14.746867
4.779618,21.619264,14.711426
4.795371,22.016555,14.740437
4.696738,22.341168,14.892376
4.477584,22.599942,15.164848
4.231383,22.852097,15.433447
4.015841,23.142931,15.607245
3.883046,23.506807,15.698075
3.843417,23.927448,15.722888
3.843261,24.357902,15.691429
3.848897,24.764405,15.613467
3.858084,25.152545,15.502619
3.887432,25.538839,15.384240
3.940508,25.930723,15.275808
3.997298,26.326991,15.177314
4.037827,26.725351,15.083692
4.064959,27.123762,14.984400
4.092111,27.520822,14.872537
4.126075,27.917939,14.758039
4.160600,28.319319,14.660700
4.182794,28.727631,14.588215
4.188529,29.137659,14.516117
4.198081,29.542902,14.428109
4.233344,29.941821,14.330272
4.280595,30.335400,14.221203
4.317711,30.724322,14.093558
4.341033,31.112127,13.952303
4.361016,31.503934,13.810793
4.381985,31.901010,13.673953
4.395503,32.294850,13.527732
4.416171,32.679101,13.373825
4.442337,33.061160,13.231333
4.453800,33.449713,13.115761
4.451444,33.845360,13.035243
4.431072,34.248688,12.984860
4.394321,34.664778,12.972779
4.360534,35.089522,12.988454
4.334121,35.515189,13.004150
4.304913,35.936599,13.003517
4.284240,36.354517,12.995340
4.268632,36.773516,12.992197
4.247043,37.195929,12.997109
4.235690,37.616715,13.002260
4.231138,38.034492,13.001582
4.231907,38.450593,12.998511
4.234457,38.867509,12.998704
4.233547,39.285874,13.001367
4.235294,39.909433,13.000000
4.705882,0.000000,13.000000
4.710327,0.418133,12.999383
4.710668,0.834734,13.000992
4.712255,1.253416,12.999533
4.724115,1.671890,12.998560
4.719783,2.088225,13.000541
4.755416,2.504354,13.003062
4.799668,2.923359,13.001194
4.897073,3.348833,12.992810
4.987133,3.770717,12.993093
5.087087,4.177171,13.014462
5.201948,4.588296,13.024668
5.297363,5.023653,12.997973
5.408458,5.467831,12.969639
5.507072,5.891235,12.995469
5.551566,6.286856,13.086656
5.544099,6.668910,13.211408
5.523471,7.039157,13.372512
5.464212,7.408984,13.532454
5.363556,7.791732,13.651085
5.282119,8.179855,13.763091
5.214995,8.570765,13.873618
5.140820,8.967235,13.964863
5.063159,9.368962,14.037503
5.001932,9.769607,14.123816
4.974377,10.162371,14.252268
4.992613,10.545583,14.425064
4.993584,10.937950,14.565333
4.969414,11.338522,14.681124
4.943429,11.741572,14.793457
4.893390,12.151871,14.862107
4.866035,12.562273,14.926865
4.882328,12.970538,15.014229
4.881043,13.383140,15.087800
4.894232,13.795061,15.168302
4.902060,14.207790,15.239033
4.874679,14.625318,15.273063
4.819438,15.048395,15.268730
4.814403,15.467801,15.278716
4.850945,15.882854,15.305700
4.868294,16.299558,15.315024
4.879878,16.715028,15.299756
5.090412,17.118461,15.355340
5.442232,17.524722,15.409713
5.583530,17.922998,15.326566
5.594999,18.316806,15.185769
5.633762,18.722208,15.086649
5.574344,19.137006,15.012324
5.445271,19.552614,14.977341
5.339812,19.964791,14.990725
5.274889,20.364497,15.020679
5.253106,20.761702,15.039799
5.271080,21.178393,15.035370
5.307227,21.616281,15.020756
5.321630,22.034090,15.049143
5.228936,22.367371,15.154070
5.026055,22.613085,15.366754
4.774503,22.853019,15.630925
4.549818,23.136664,15.836879
4.399032,23.484071,15.959115
4.341756,23.899642,16.007160
4.329454,24.335457,15.988972
4.326553,24.748778,15.914682
4.329220,25.140813,15.803370
4.354557,25.530330,15.682328
4.408083,25.926030,15.569304
4.468042,26.325687,15.464091
4.512114,26.726001,15.362265
4.540806,27.125569,15.258051
4.565351,27.524838,15.149677
4.592076,27.926498,15.046674
4.616953,28.333878,14.963190
4.630782,28.747648,14.901274
4.629580,29.161579,14.837208
4.633552,29.569999,14.755654
4.666663,29.972041,14.658851
4.713535,30.369033,14.547510
4.748126,30.762013,14.420291
4.766592,31.153729,14.283608
4.781873,31.547835,14.146578
4.799708,31.945106,14.011750
4.811403,32.339459,13.868259
4.827866,32.728543,13.720277
4.849851,33.115691,13.576665
4.872688,33.498918,13.431900
4.905069,33.872394,13.277882
4.917650,34.241434,13.119776
4.896641,34.631940,13.019630
4.869367,35.050031,12.997755
4.839771,35.476025,13.008201
4.805723,35.895162,13.012264
4.782896,36.308887,13.005990
4.764741,36.724017,12.999590
4.739810,37.143572,12.999344
4.726978,37.563690,13.001756
4.722004,37.981517,13.001653
4.723613,38.398058,12.999817
4.727548,38.815556,12.999361
4.727308,39.234192,13.000438
4.705882,39.909433,13.000000
5.176471,0.000000,13.000000
5.181404,0.420047,12.998395
5.181831,0.835961,13.002590
5.183582,1.257493,12.998776
5.196759,1.678239,12.996529
5.192097,2.093672,13.001344
5.231912,2.509593,13.006203
5.280459,2.932169,13.001997
5.389419,3.362135,12.993740
5.488584,3.784789,12.997495
5.599073,4.207760,12.999023
5.738261,4.650601,12.979097
5.853943,5.079765,12.991606
5.935151,5.468116,13.077078
5.969980,5.829072,13.223444
5.968453,6.180774,13.411959
5.931754,6.543360,13.596436
5.896677,6.909379,13.788700
5.837647,7.284734,13.958501
5.734849,7.675393,14.082974
5.645085,8.068296,14.207390
5.574455,8.463603,14.330482
5.497199,8.864752,14.429696
5.412105,9.270338,14.503466
5.350734,9.675220,14.581892
5.340141,10.073868,14.695972
5.388875,10.465953,14.854396
5.412629,10.867901,14.976693
5.405515,11.276969,15.068598
5.402998,11.689026,15.157254
5.367178,12.105813,15.205185
5.347912,12.520818,15.252303
5.377805,12.933198,15.330468
5.385866,13.347994,15.397660
5.408872,13.763562,15.472533
5.424632,14.179142,15.538536
5.395941,14.595388,15.568421
5.331233,15.014083,15.556685
5.325753,15.434191,15.556973
5.370455,15.854459,15.575692
5.393037,16.274857,15.577861
5.408586,16.693527,15.556002
5.666430,17.113253,15.584685
6.076258,17.515699,15.620164
6.221113,17.920262,15.549072
6.225746,18.333953,15.411409
6.270487,18.745898,15.299896
6.209472,19.173649,15.199186
6.070308,19.600371,15.146303
5.956576,20.006772,15.164343
5.886332,20.398427,15.213038
5.866125,20.798364,15.238511
5.888441,21.230166,15.213982
5.923317,21.677638,15.187014
5.923613,22.093258,15.247997
5.806381,22.433982,15.407575
5.593418,22.681350,15.609372
5.325819,22.891612,15.826756
5.092689,23.166414,16.021525
4.939790,23.509336,16.153129
4.879003,23.912606,16.211943
4.861237,24.340672,16.203481
4.852842,24.757216,16.143279
4.851082,25.155912,16.047513
4.871760,25.551025,15.935181
4.921565,25.952627,15.824192
4.978961,26.358974,15.718107
5.021364,26.764769,15.614896
5.046018,27.168787,15.514363
5.060695,27.573885,15.420054
5.073345,27.983308,15.337330
5.086365,28.397478,15.268766
5.095303,28.814222,15.209368
5.092018,29.228100,15.141393
5.093207,29.637377,15.056204
5.124190,30.044092,14.956101
5.168794,30.448503,14.842277
5.198447,30.849212,14.716173
5.209674,31.247209,14.585091
5.217249,31.645259,14.455708
5.229213,32.044430,14.329787
5.236532,32.442520,14.200937
5.243111,32.842442,14.074330
5.254720,33.240871,13.943830
5.283821,33.625036,13.782801
5.344431,33.985698,13.568547
5.387121,34.329546,13.318861
5.391749,34.692789,13.124510
5.384705,35.092575,13.030291
5.357745,35.506992,13.001753
5.320209,35.921904,13.004016
5.296132,36.335705,13.009729
5.276470,36.749349,13.008419
5.249804,37.163912,13.002553
5.236255,37.581587,12.999008
5.231351,38.000132,12.999874
5.233836,38.419236,13.001672
5.238958,38.838825,13.000908
5.239456,39.258008,12.998750
5.176471,39.909433,13.000000
5.647059,0.000000,13.000000
5.652497,0.420854,13.000613
5.652863,0.842783,12.999040
5.654963,1.263289,13.000494
5.669561,1.684224,13.001496
5.664227,2.106448,12.999265
5.707110,2.531366,12.996078
5.763807,2.954791,12.998803
5.887128,3.373278,13.014164
5.987849,3.798541,13.014507
6.109541,4.263506,12.965659
6.270143,4.727965,12.943437
6.382334,5.102049,13.065366
6.405646,5.398277,13.305069
6.367947,5.690776,13.571141
6.326829,6.007028,13.837362
6.274818,6.359927,14.061106
6.235968,6.730642,14.260427
6.186907,7.120820,14.415178
6.101340,7.531151,14.518852
6.022551,7.941777,14.624764
5.962726,8.353025,14.733233
5.895831,8.769059,14.822376
5.812850,9.185574,14.893534
5.751522,9.596397,14.975190
5.751954,10.001454,15.092612
5.823324,10.404265,15.252985
5.865058,10.817098,15.369173
5.879705,11.235494,15.435303
5.906484,11.654500,15.487544
5.879318,12.078054,15.517688
5.855976,12.499986,15.565979
5.892896,12.917555,15.644683
5.913219,13.336173,15.695531
5.950355,13.754219,15.748204
5.975417,14.173738,15.796888
5.947871,14.595985,15.817854
5.875862,15.018484,15.804165
5.871830,15.440229,15.797555
5.927785,15.861466,15.798830
5.959637,16.279957,15.778047
5.981001,16.698640,15.742674
6.262926,17.102819,15.772079
6.671546,17.460711,15.852495
6.811268,17.843660,15.802688
6.821782,18.232585,15.651199
6.877207,18.606884,15.500937
6.821329,19.038450,15.346645
6.680459,19.512929,15.255533
6.570030,19.959743,15.255341
6.504879,20.377728,15.295740
6.487111,20.794711,15.304043
6.509290,21.231758,15.247281
6.540548,21.665851,15.208456
6.533273,22.066691,15.296478
6.406051,22.435427,15.535426
6.181367,22.747918,15.826230
5.893828,22.985230,16.072798
5.646213,23.243596,16.251870
5.491764,23.582796,16.362082
5.433363,23.984675,16.406888
5.414834,24.410080,16.393022
5.402530,24.826451,16.340886
5.395696,25.228812,16.261302
5.408707,25.631359,16.162800
5.449248,26.044861,16.061494
5.496452,26.464141,15.964895
5.528095,26.879352,15.873383
5.541827,27.289684,15.785372
5.545906,27.700479,15.702513
5.549161,28.115863,15.628500
5.555271,28.534944,15.563760
5.560636,28.954009,15.503091
5.555926,29.367467,15.430951
5.555954,29.777273,15.340748
5.584466,30.189607,15.236582
5.624823,30.601991,15.119763
5.649438,31.008571,14.990782
5.656883,31.409881,14.856745
5.661720,31.809991,14.724605
5.671588,32.210951,14.596117
5.676354,32.611963,14.467888
5.677422,33.017553,14.344859
5.684023,33.420716,14.213450
5.712969,33.806069,14.042107
5.776215,34.166406,13.811135
5.825948,34.505219,13.539422
5.855545,34.849782,13.287217
5.878807,35.219763,13.100103
5.861776,35.608618,12.989960
5.821978,36.020016,12.968795
5.795153,36.444429,12.990651
5.773702,36.865689,13.006844
5.745601,37.278627,13.002808
5.731020,37.694109,12.994900
5.725979,38.114757,12.996192
5.728358,38.538674,13.001759
5.733391,38.961987,13.002148
5.733715,39.382639,12.997941
5.647059,39.909433,13.000000
6.117647,0.000000,13.000000
6.123590,0.421696,13.003967
6.123821,0.853168,12.993692
6.126345,1.271478,13.002992
6.142367,1.692520,13.008461
6.136225,2.125151,12.996356
6.181921,2.561384,12.984053
6.246619,2.983377,12.996140
6.381032,3.395495,13.024294
6.490073,3.835716,13.012821
6.622215,4.313742,12.973191
6.762131,4.728589,13.047166
6.825426,5.006366,13.301833
6.796841,5.226287,13.638319
6.727333,5.486118,13.957780
6.680184,5.797021,14.251857
6.631174,6.152833,14.493511
6.593078,6.526476,14.699110
6.549748,6.925911,14.847012
6.482164,7.355463,14.931903
6.422463,7.787215,15.011361
6.378306,8.216064,15.097715
6.323663,8.648688,15.171587
6.248160,9.082014,15.231994
6.192795,9.504099,15.310154
6.205038,9.913998,15.428050
6.298281,10.314134,15.580827
6.356258,10.724279,15.686409
6.382586,11.144443,15.744256
6.421649,11.562768,15.786963
6.397938,11.995614,15.807870
6.375316,12.425580,15.848338
6.424464,12.838412,15.912048
6.453924,13.257910,15.945619
6.497210,13.673236,15.981710
6.529614,14.090971,16.016588
6.507343,14.524804,16.027568
6.431829,14.970664,16.012028
6.425791,15.399304,16.005087
6.482900,15.813331,16.003192
6.514464,16.228604,15.977452
6.534745,16.647083,15.937388
6.807640,17.003502,16.001429
7.221256,17.316593,16.117900
7.376960,17.672860,16.073618
7.392561,18.042945,15.915260
7.458716,18.402103,15.742263
7.405054,18.812246,15.531182
7.260831,19.279064,15.366172
7.158659,19.747452,15.294458
7.101603,20.197158,15.255757
7.071291,20.639509,15.204558
7.072526,21.075294,15.141328
7.094230,21.489232,15.122368
7.092713,21.878763,15.208503
6.980439,22.263603,15.444291
6.760550,22.637057,15.818854
6.464844,22.979313,16.207615
6.204313,23.288045,16.470824
6.042636,23.652681,16.596796
5.983141,24.082304,16.627284
5.964227,24.525858,16.598155
5.948038,24.943899,16.540351
5.934381,25.345935,16.465225
5.937363,25.754341,16.377948
5.966066,26.176886,16.290412
5.999120,26.603036,16.210682
6.014396,27.023032,16.140248
6.014050,27.437831,16.069190
6.010993,27.852122,15.990463
6.013260,28.269238,15.909845
6.019028,28.689191,15.837075
6.021380,29.109828,15.773778
6.014160,29.526109,15.701837
6.013573,29.937887,15.610141
6.039989,30.349369,15.503206
6.076238,30.758800,15.382883
6.097423,31.162902,15.248046
6.104772,31.563153,15.105143
6.111497,31.962413,14.962436
6.122540,32.362404,14.822381
6.126670,32.763870,14.682641
6.127059,33.169438,14.547501
6.133755,33.570822,14.405318
6.157546,33.954574,14.234035
6.206583,34.315270,14.024202
6.248853,34.655629,13.775425
6.293833,34.987099,13.501307
6.341530,35.325127,13.241168
6.338399,35.686722,13.044524
6.303729,36.092132,12.968821
6.276104,36.525504,12.975163
6.251770,36.959267,12.995903
6.221631,37.382339,12.999424
6.205862,37.803052,12.994812
6.200477,38.228070,12.995462
6.202413,38.655799,12.999847
6.207091,39.082095,13.001266
6.206977,39.506070,12.999177
6.117647,39.909433,13.000000
6.588235,0.000000,13.000000
6.594643,0.425610,13.003150
6.594867,0.861377,12.995108
6.597604,1.283581,13.002050
6.614839,1.709254,13.005890
6.608259,2.145692,12.997477
6.658127,2.583107,12.991582
6.724495,3.006556,13.000195
6.863386,3.441423,12.997196
6.995900,3.900760,12.986091
7.126210,4.324578,13.059567
7.204376,4.632794,13.290191
7.202979,4.816694,13.648980
7.141545,4.989442,14.023412
7.073612,5.244279,14.344418
7.045968,5.570742,14.626270
7.015781,5.938543,14.863325
6.984429,6.311994,15.074426
6.943223,6.711233,15.227442
6.888297,7.150967,15.304621
6.848612,7.597617,15.364532
6.817843,8.035811,15.437461
6.766331,8.475905,15.506126
6.694507,8.924812,15.552851
6.651943,9.362725,15.607802
6.685247,9.773761,15.697235
6.809405,10.150421,15.808025
6.883830,10.539138,15.889726
6.899900,10.949057,15.971677
6.917512,11.358989,16.062351
6.891161,11.798963,16.085512
6.889009,12.233220,16.083185
6.962646,12.633972,16.106712
6.993807,13.052132,16.132589
7.029813,13.465040,16.175295
7.066876,13.878965,16.209790
7.052310,14.320606,16.211662
6.974380,14.791417,16.189379
6.958905,15.232108,16.189741
7.005128,15.643241,16.209675
7.025833,16.063805,16.208912
7.039414,16.487923,16.176416
7.332031,16.816390,16.236902
7.820111,17.071944,16.326267
7.984565,17.432368,16.305809
7.978071,17.877238,16.191070
8.037665,18.295286,16.062590
7.981929,18.706768,15.836952
7.841746,19.119467,15.585883
7.750053,19.547565,15.409432
7.700841,19.985991,15.256396
7.663274,20.427370,15.110007
7.650787,20.854080,15.011634
7.661013,21.261613,14.995216
7.647235,21.659296,15.086381
7.528779,22.041617,15.301774
7.312859,22.391026,15.659449
7.021378,22.763621,16.116813
6.753927,23.152364,16.504151
6.583854,23.574226,16.716716
6.517668,24.036496,16.783110
6.492926,24.500280,16.769689
6.471994,24.930076,16.719243
6.454058,25.341218,16.648659
6.450038,25.756209,16.568374
6.469115,26.177616,16.491151
6.490280,26.599961,16.426296
6.493042,27.022186,16.373845
6.482786,27.444605,16.317690
6.475254,27.865752,16.244486
6.477567,28.285432,16.160289
6.483667,28.705509,16.080854
6.484024,29.128277,16.013692
6.474620,29.552074,15.942584
6.472943,29.969179,15.853366
6.497075,30.374641,15.747381
6.530165,30.772621,15.625816
6.548953,31.170765,15.488199
6.556060,31.570712,15.340882
6.563783,31.969960,15.191561
6.574976,32.368433,15.043205
6.578489,32.770298,14.894347
6.578956,33.176214,14.749600
6.585636,33.577583,14.603025
6.604070,33.961269,14.440182
6.641300,34.319336,14.254223
6.675017,34.659511,14.027065
6.718016,34.984421,13.757096
6.769358,35.304434,13.480050
6.780238,35.647380,13.234896
6.764500,36.031328,13.076554
6.743594,36.447970,13.001630
6.716008,36.882838,12.982700
6.684169,37.324187,12.993400
6.668631,37.760136,13.005457
6.663376,38.190603,13.004294
6.665763,38.617657,12.996810
6.671333,39.045068,12.996467
6.671826,39.475255,13.003187
6.588235,39.909433,13.000000
7.058824,0.000000,13.000000
7.065644,0.433185,12.997429
7.066014,0.865737,13.004445
7.068680,1.299747,12.997040
7.086872,1.734498,12.993464
7.080343,2.165718,13.003888
7.135168,2.596589,13.015539
7.200440,3.033598,13.002349
7.345630,3.502867,12.959780
7.492702,3.940940,13.002268
7.591196,4.259678,13.232078
7.602908,4.465462,13.592794
7.560741,4.593565,14.009322
7.489688,4.746270,14.395251
7.431892,5.002421,14.709327
7.421787,5.341898,14.976486
7.409823,5.719546,15.204417
7.390520,6.093749,15.415331
7.355425,6.491584,15.570362
7.311380,6.934961,15.641582
7.289473,7.389028,15.685505
7.271760,7.829641,15.746166
7.220491,8.268835,15.813149
7.144885,8.723989,15.855469
7.112279,9.174086,15.886075
7.168162,9.586349,15.936176
7.319534,9.945234,16.011306
7.404882,10.319834,16.078366
7.404446,10.717140,16.191328
7.389470,11.116234,16.345150
7.349531,11.554210,16.383021
7.367359,11.989319,16.340651
7.461440,12.389226,16.336949
7.499392,12.806776,16.348827
7.538506,13.217507,16.385366
7.583120,13.630895,16.409428
7.574117,14.076217,16.396510
7.495971,14.554499,16.361129
7.476558,15.002400,16.362298
7.522755,15.417727,16.389888
7.546379,15.844796,16.393810
7.563775,16.276286,16.364357
7.910798,16.588812,16.392224
8.426542,16.760803,16.498698
8.562045,17.140051,16.521126
8.533416,17.662383,16.461053
8.574654,18.120976,16.388923
8.516892,18.580542,16.190181
8.396049,19.007494,15.903925
8.323865,19.402359,15.648493
8.286634,19.806985,15.402458
8.261736,20.222299,15.158428
8.257483,20.632573,14.973952
8.255465,21.042973,14.912137
8.209806,21.462458,15.013707
8.058506,21.874093,15.264282
7.832381,22.208461,15.613559
7.552704,22.516345,16.018386
7.289465,22.891137,16.414222
7.113088,23.323012,16.688916
7.034895,23.777254,16.827203
6.996410,24.235824,16.872869
6.969079,24.679681,16.858773
6.951501,25.109772,16.803902
6.946653,25.534287,16.727716
6.961076,25.953646,16.654145
6.976205,26.374508,16.597441
6.975505,26.802685,16.552318
6.963456,27.235733,16.503965
6.953174,27.667552,16.442003
6.951435,28.094785,16.368592
6.954426,28.519034,16.292704
6.953668,28.945578,16.221633
6.943191,29.377563,16.149803
6.939258,29.803409,16.066863
6.960070,30.210972,15.967693
6.990519,30.607881,15.849483
7.007022,31.008521,15.714336
7.011882,31.413936,15.570120
7.017315,31.818131,15.422221
7.025973,32.219614,15.273188
7.028092,32.624067,15.123151
7.027384,33.033462,14.978390
7.031774,33.442453,14.837809
7.047121,33.836782,14.684824
7.081334,34.204283,14.505726
7.109412,34.553360,14.281835
7.138022,34.888403,14.026264
7.178417,35.215542,13.767849
7.199788,35.551424,13.507967
7.208057,35.903578,13.268347
7.199853,36.281515,13.080422
7.172260,36.696844,12.986574
7.140481,37.143702,12.988846
7.125979,37.592418,13.017882
7.121437,38.027177,13.015853
7.125364,38.453109,12.994679
7.132835,38.883310,12.991376
7.134721,39.320953,13.007047
7.058824,39.909433,13.000000
7.529412,0.000000,13.000000
7.536613,0.441533,12.992560
7.537068,0.870362,13.012377
7.539600,1.318206,12.992350
7.558654,1.760677,12.985055
7.552283,2.185206,13.012099
7.610163,2.618447,13.028356
7.682403,3.087425,12.984470
7.841768,3.562683,12.955758
7.966240,3.907387,13.122586
8.001919,4.107006,13.483331
7.968635,4.252118,13.900851
7.928847,4.376141,14.322485
7.876110,4.537092,14.708619
7.821296,4.789149,15.036508
7.804635,5.120781,15.317641
7.795643,5.496802,15.549067
7.791596,5.876232,15.751872
7.772415,6.279895,15.893153
7.740247,6.725161,15.951468
7.730263,7.181324,15.977531
7.728484,7.624291,16.013045
7.687651,8.066085,16.061697
7.604790,8.523372,16.113128
7.563221,8.978108,16.159693
7.620679,9.395498,16.216484
7.779492,9.762297,16.308849
7.869670,10.145639,16.377550
7.868845,10.536288,16.491695
7.840088,10.924496,16.666923
7.772150,11.354679,16.733896
7.781859,11.790820,16.705757
7.880530,12.198177,16.708384
7.944176,12.607641,16.676156
8.014333,13.005120,16.661110
8.072434,13.413865,16.649159
8.066786,13.860745,16.611029
7.993608,14.338590,16.553909
7.987142,14.783724,16.535930
8.054161,15.197628,16.532583
8.099400,15.622393,16.501674
8.130659,16.056480,16.470253
8.474109,16.331732,16.545312
8.901511,16.447405,16.739321
9.009669,16.815081,16.768861
8.995335,17.295270,16.718542
9.027116,17.711915,16.656358
8.965540,18.227036,16.489889
8.859994,18.750537,16.231617
8.804633,19.179720,15.962131
8.777531,19.579254,15.676928
8.765466,19.977214,15.373575
8.771349,20.371300,15.111687
8.769374,20.768802,14.978374
8.722011,21.183605,15.026065
8.564179,21.643873,15.263915
8.330492,22.051342,15.651313
8.058269,22.368754,16.062548
7.811449,22.694184,16.420170
7.637452,23.087041,16.682512
7.548483,23.509312,16.855295
7.496837,23.946486,16.951381
7.463190,24.392799,16.980900
7.444958,24.836229,16.951989
7.439665,25.270227,16.883454
7.451548,25.695577,16.811313
7.464103,26.123284,16.756747
7.463944,26.558576,16.710939
7.453345,26.998519,16.663516
7.441412,27.438015,16.610530
7.434584,27.873347,16.550747
7.432971,28.304327,16.483431
7.430287,28.735659,16.412647
7.418144,29.172464,16.342603
7.410945,29.606628,16.268708
7.427504,30.026724,16.180152
7.454701,30.436604,16.067639
7.468509,30.847112,15.934342
7.470743,31.260127,15.791962
7.473129,31.671687,15.646099
7.478610,32.079888,15.498009
7.479229,32.488289,15.348022
7.476990,32.901735,15.204393
7.478247,33.320602,15.070579
7.490664,33.731034,14.925519
7.523414,34.118344,14.746142
7.547135,34.483183,14.518431
7.562968,34.834626,14.270654
7.592587,35.180418,14.025927
7.617512,35.521131,13.761729
7.640564,35.857712,13.473834
7.645833,36.207787,13.205690
7.626652,36.596293,13.034614
7.598533,37.028704,12.992337
7.583442,37.477451,13.009794
7.579740,37.917044,13.011445
7.585618,38.349542,12.996472
7.594365,38.786914,12.994171
7.596838,39.229614,13.004770
7.529412,39.909433,13.000000
8.000000,0.000000,13.000000
8.007572,0.448254,12.993097
8.007828,0.880276,13.011338
8.010421,1.337346,12.992197
8.030356,1.783466,12.989798
8.023536,2.209275,13.016295
8.081828,2.661653,13.015060
8.168444,3.158912,12.961493
8.330251,3.582744,13.021933
8.404446,3.803804,13.333184
8.378131,3.906724,13.779106
8.320828,4.018284,14.208308
8.302288,4.155482,14.611585
8.279345,4.334299,14.992443
8.225975,4.582943,15.343160
8.188872,4.896094,15.657051
8.170822,5.262779,15.905096
8.179968,5.649057,16.100196
8.181731,6.064484,16.218646
8.163696,6.513637,16.256628
8.161563,6.969212,16.261781
8.176979,7.414739,16.262356
8.157805,7.866921,16.271042
8.073416,8.334539,16.325116
8.003673,8.791712,16.429826
8.037838,9.212666,16.550110
8.188402,9.590463,16.690092
8.275855,9.987391,16.768797
8.290875,10.376938,16.861177
8.274892,10.757798,17.014011
8.179878,11.188437,17.111035
8.156901,11.626770,17.138910
8.250156,12.029382,17.157421
8.341275,12.422732,17.078422
8.445735,12.799905,17.007033
8.519870,13.192749,16.957901
8.525770,13.629295,16.885666
8.466145,14.107237,16.786934
8.477306,14.547148,16.732796
8.555822,14.953790,16.704778
8.599858,15.379949,16.669182
8.628988,15.815617,16.648674
8.899763,16.042378,16.834356
9.228625,16.164562,17.081118
9.340295,16.494967,17.086832
9.364660,16.859352,17.015170
9.399733,17.202837,16.932088
9.336248,17.737574,16.775952
9.232196,18.347631,16.558875
9.179515,18.846851,16.322078
9.153637,19.273844,16.048686
9.140541,19.674542,15.736129
9.145712,20.058478,15.438214
9.158058,20.423680,15.231090
9.150173,20.789581,15.150731
9.036435,21.251896,15.239083
8.826215,21.756215,15.586841
8.559405,22.192471,16.066267
8.324925,22.550525,16.474109
8.158581,22.939876,16.747705
8.065114,23.362629,16.923086
8.009444,23.799284,17.037667
7.973169,24.245505,17.102434
7.949611,24.694633,17.108094
7.938949,25.138250,17.057461
7.946798,25.575323,16.989451
7.957050,26.012205,16.932766
7.956376,26.452588,16.882688
7.945805,26.896250,16.831771
7.932952,27.340401,16.778920
7.923684,27.781978,16.723782
7.918596,28.220122,16.663694
7.912043,28.657964,16.600280
7.896293,29.099150,16.538203
7.885309,29.540116,16.474864
7.897169,29.973894,16.397406
7.919818,30.398420,16.290048
7.930367,30.817721,16.153731
7.931126,31.236019,16.005656
7.931998,31.653744,15.856557
7.935445,32.068865,15.706076
7.935071,32.481812,15.551868
7.931924,32.898825,15.403488
7.930702,33.324472,15.269560
7.938689,33.746940,15.129521
7.966292,34.150104,14.953935
7.986178,34.526226,14.725832
7.999040,34.885964,14.472632
8.025444,35.241952,14.220483
8.046634,35.590843,13.952023
8.070377,35.932149,13.657930
8.086127,36.278520,13.365803
8.083002,36.652131,13.136705
8.062818,37.064667,13.014538
8.045161,37.503312,12.979333
8.042068,37.950524,12.985971
8.049967,38.398956,13.002523
8.058764,38.845905,13.006870
8.060252,39.289575,12.995075
8.000000,39.909433,13.000000
8.470588,0.000000,13.000000
8.478538,0.453161,12.998604
8.478135,0.901909,13.001265
8.481248,1.356419,12.999243
8.502052,1.808236,13.002223
8.492667,2.256488,13.005240
8.552156,2.730797,12.986969
8.643878,3.197683,12.990789
8.770924,3.515002,13.189626
8.797121,3.647399,13.601411
8.743866,3.704868,14.082233
8.679549,3.789370,14.514091
8.671343,3.916236,14.910933
8.664953,4.094678,15.292753
8.617433,4.344151,15.658487
8.567817,4.647980,15.998931
8.539758,5.006151,16.269397
8.554269,5.394045,16.469168
8.571866,5.817888,16.573161
8.570497,6.272700,16.589940
8.578273,6.727143,16.573842
8.606695,7.168697,16.548446
8.607708,7.625326,16.518232
8.538053,8.109507,16.538708
8.452692,8.577746,16.668314
8.457744,8.998405,16.856779
8.576523,9.370281,17.061446
8.640721,9.771777,17.174688
8.678760,10.162170,17.247341
8.700686,10.539487,17.353002
8.606958,10.978710,17.450020
8.547708,11.423326,17.527888
8.622518,11.812594,17.567964
8.713042,12.195574,17.493652
8.824311,12.562951,17.417553
8.915645,12.934324,17.353605
8.949353,13.343559,17.240962
8.913317,13.814118,17.075438
8.931925,14.254157,16.976309
8.988806,14.661795,16.970299
8.980832,15.105709,17.006552
8.976133,15.545941,17.016450
9.192506,15.746926,17.260113
9.469590,15.924992,17.511354
9.597966,16.222293,17.509666
9.660632,16.491651,17.419301
9.707338,16.792951,17.311469
9.653618,17.295076,17.131558
9.550606,17.919374,16.925592
9.494404,18.468043,16.723554
9.465493,18.928083,16.481090
9.443670,19.343822,16.188271
9.439700,19.727853,15.885966
9.467485,20.065283,15.621765
9.508671,20.379920,15.408219
9.459261,20.803821,15.290501
9.305870,21.333693,15.461045
9.067804,21.874398,15.891029
8.836785,22.321828,16.364830
8.668079,22.743555,16.717973
8.568883,23.188598,16.938588
8.513010,23.645871,17.086688
8.477381,24.104000,17.191192
8.448799,24.563752,17.237125
8.431393,25.021172,17.215645
8.433783,25.470971,17.162318
8.441261,25.916528,17.109218
8.439895,26.363628,17.057477
8.429536,26.814555,17.002067
8.417161,27.266986,16.944549
8.408083,27.717577,16.888636
8.401599,28.165569,16.833405
8.391894,28.613842,16.777862
8.373295,29.065431,16.723256
8.359575,29.516569,16.668672
8.367183,29.960303,16.602221
8.384762,30.393798,16.503003
8.392097,30.820303,16.366753
8.392327,31.244677,16.213438
8.392951,31.669046,16.059381
8.395398,32.091365,15.904241
8.394557,32.511007,15.743782
8.391508,32.933554,15.587960
8.389486,33.364836,15.449061
8.393433,33.795456,15.311142
8.414873,34.207160,15.142444
8.431927,34.590231,14.918003
8.446404,34.953983,14.656984
8.473590,35.312748,14.391551
8.489944,35.668385,14.117954
8.508695,36.019939,13.832191
8.530156,36.372232,13.541765
8.541566,36.740400,13.276011
8.531281,37.137520,13.073662
8.512504,37.564895,12.967351
8.509574,38.019060,12.963874
8.520039,38.484271,13.007533
8.529265,38.941064,13.018924
8.529140,39.386344,12.986141
8.470588,39.909433,13.000000
8.941176,0.000000,13.000000
8.949527,0.456715,13.007124
8.947929,0.938898,12.984751
8.952179,1.374792,13.014243
8.973762,1.840195,13.014393
8.958597,2.339745,12.972063
9.022549,2.819459,12.962895
9.099136,3.171358,13.106474
9.160260,3.362655,13.445088
9.157972,3.461622,13.894741
9.116685,3.522513,14.370579
9.057906,3.580818,14.813595
9.035608,3.660083,15.232678
9.021136,3.809293,15.628236
8.982863,4.059016,15.997028
8.940590,4.370378,16.343239
8.909782,4.725960,16.635502
8.919691,5.108734,16.857589
8.942974,5.535019,16.964111
8.959541,5.996578,16.964783
8.982181,6.451613,16.929769
9.017120,6.883852,16.895156
9.029194,7.331839,16.842215
8.991091,7.822184,16.790346
8.928911,8.305971,16.850694
8.916647,8.723142,17.064965
8.974685,9.078574,17.357816
8.992281,9.479411,17.543408
9.049768,9.872767,17.618417
9.121828,10.252783,17.674655
9.070829,10.692481,17.720779
8.993630,11.142200,17.800211
9.034385,11.533596,17.881306
9.087796,11.933194,17.888069
9.175581,12.318195,17.864376
9.281232,12.682143,17.803634
9.347396,13.068047,17.652693
9.337831,13.523021,17.419804
9.359221,13.968613,17.283519
9.380135,14.385166,17.320240
9.292329,14.839507,17.448547
9.229425,15.278454,17.501512
9.422445,15.486461,17.752570
9.687027,15.740827,18.016366
9.825314,16.031938,18.061242
9.905439,16.290384,17.971995
9.968364,16.601094,17.843146
9.940705,17.040021,17.616408
9.852095,17.580882,17.368824
9.796278,18.109932,17.162533
9.766342,18.582320,16.937703
9.736386,19.017231,16.670326
9.718487,19.415754,16.382804
9.748786,19.754950,16.096838
9.816399,20.061091,15.815640
9.816075,20.449288,15.552131
9.727879,20.943852,15.509366
9.546797,21.505938,15.753624
9.335680,22.003809,16.157585
9.160083,22.432284,16.545862
9.048332,22.867007,16.843140
8.987253,23.329020,17.060287
8.951489,23.800862,17.215221
8.922276,24.275351,17.299536
8.901178,24.748128,17.314871
8.898091,25.211154,17.293770
8.902770,25.668852,17.260506
8.902473,26.127944,17.215159
8.894841,26.590046,17.156947
8.884733,27.053913,17.095663
8.877115,27.517189,17.040629
8.871464,27.978600,16.988411
8.862544,28.440159,16.932604
8.845203,28.906104,16.875177
8.831458,29.371558,16.823232
8.836250,29.826856,16.769004
8.849426,30.271465,16.687080
8.854298,30.710691,16.564354
8.854272,31.147141,16.416759
8.855023,31.582100,16.261448
8.856961,32.014532,16.101634
8.856032,32.444625,15.936676
8.854211,32.876308,15.776108
8.853805,33.315374,15.631461
8.856584,33.755942,15.492150
8.874546,34.177302,15.328066
8.890016,34.571205,15.109162
8.904198,34.944746,14.848541
8.932031,35.308252,14.577302
8.948104,35.669059,14.295412
8.963874,36.026456,14.005952
8.984966,36.383495,13.714311
9.001684,36.750689,13.432007
9.000631,37.138340,13.179351
8.985064,37.556520,13.008238
8.981743,38.012338,12.967236
8.995354,38.488859,13.006623
9.006534,38.956316,13.020879
9.005202,39.408362,12.985245
8.941176,39.909433,13.000000
9.411765,0.000000,13.000000
9.420585,0.461009,13.012689
9.417755,0.974308,12.972965
9.423167,1.391568,13.027224
9.445281,1.874749,13.017611
9.423362,2.423589,12.942069
9.490434,2.879625,12.980294
9.539019,3.097510,13.279822
9.535674,3.185980,13.724553
9.521440,3.275342,14.180749
9.506673,3.351925,14.639367
9.456745,3.390501,15.095992
9.412409,3.421109,15.546794
9.382425,3.539351,15.961619
9.355146,3.789173,16.330623
9.329769,4.113073,16.672755
9.301558,4.468904,16.981761
9.305454,4.848967,17.227319
9.331566,5.281429,17.339730
9.362826,5.752846,17.329884
9.396650,6.211267,17.282005
9.434258,6.639514,17.243062
9.456662,7.082161,17.170782
9.452651,7.569334,17.047229
9.427493,8.053114,17.010097
9.411359,8.459583,17.222162
9.413881,8.802903,17.603307
9.378557,9.192249,17.871485
9.436364,9.587086,17.977699
9.538586,9.981193,18.010203
9.541459,10.421526,17.990660
9.476295,10.874112,18.027717
9.492522,11.287107,18.150319
9.500389,11.712188,18.258788
9.543690,12.124079,18.306743
9.647654,12.503213,18.259894
9.733039,12.894948,18.084184
9.743725,13.341169,17.814047
9.776463,13.792819,17.667955
9.773351,14.208786,17.726715
9.608619,14.631879,17.893525
9.472311,15.051392,17.996539
9.660076,15.301933,18.241338
9.927428,15.606841,18.568216
10.055268,15.905685,18.691364
10.132060,16.211462,18.614197
10.209696,16.557619,18.466223
10.214120,16.936626,18.192663
10.153344,17.358972,17.882267
10.108198,17.812975,17.633115
10.084086,18.270725,17.399441
10.054109,18.721889,17.146161
10.023425,19.146875,16.879270
10.036839,19.519226,16.611149
10.098199,19.856010,16.339209
10.116711,20.237005,16.034242
10.072949,20.691239,15.863811
9.954832,21.213723,15.918805
9.795080,21.706939,16.151475
9.635552,22.121819,16.460134
9.519485,22.523992,16.772485
9.453522,22.966872,17.033159
9.417039,23.438030,17.220262
9.388726,23.916787,17.326485
9.365339,24.395508,17.370553
9.357766,24.869240,17.383336
9.360511,25.341580,17.375331
9.362037,25.813994,17.340903
9.357586,26.284993,17.282942
9.349731,26.756424,17.220161
9.343382,27.229605,17.167152
9.339265,27.702537,17.116134
9.333146,28.173990,17.054714
9.319070,28.648000,16.987949
9.306816,29.123380,16.933805
9.310262,29.592901,16.891437
9.320311,30.055281,16.831790
9.323096,30.512158,16.731544
9.322169,30.963572,16.598421
9.322515,31.410796,16.446133
9.323728,31.854654,16.283008
9.322620,32.295893,16.115775
9.322172,32.737023,15.953333
9.324271,33.184086,15.803281
9.327830,33.635964,15.659319
9.344527,34.072442,15.495430
9.358552,34.483315,15.282678
9.369178,34.872910,15.029302
9.395691,35.246436,14.756032
9.413818,35.612254,14.462087
9.428265,35.973834,14.160221
9.444965,36.337047,13.865287
9.459974,36.706885,13.577923
9.465107,37.087354,13.296495
9.454814,37.495096,13.074259
9.450819,37.947183,12.985021
9.465924,38.430142,13.000603
9.478800,38.908357,13.015549
9.477246,39.370051,12.990179
9.411765,39.909433,13.000000
9.882353,0.000000,13.000000
9.891741,0.468610,13.008220
9.888351,0.984168,12.979630
9.894094,1.405858,13.024791
9.916311,1.904245,13.003958
9.890036,2.457272,12.950428
9.952717,2.859931,13.074333
9.971084,3.000655,13.472759
9.933765,3.042175,13.966389
9.919872,3.115519,14.428475
9.922905,3.185725,14.883547
9.876024,3.215219,15.349569
9.820810,3.236000,15.819050
9.788524,3.353265,16.249217
9.775021,3.608746,16.623575
9.763656,3.939215,16.965958
9.739472,4.294952,17.282250
9.746141,4.683507,17.531934
9.780706,5.135057,17.637496
9.818281,5.621356,17.622229
9.848648,6.084975,17.572445
9.887381,6.521266,17.523323
9.928731,6.977686,17.420651
9.947793,7.467355,17.261878
9.933562,7.934594,17.201633
9.922070,8.317538,17.421563
9.921903,8.644045,17.834794
9.847666,9.000241,18.159752
9.871010,9.388597,18.328926
9.954279,9.806447,18.381792
9.989145,10.263512,18.323834
9.967532,10.725983,18.300857
9.997547,11.165969,18.430843
9.979842,11.601763,18.602146
9.967370,12.028266,18.705008
10.043980,12.435452,18.675259
10.126560,12.852498,18.490076
10.145488,13.301824,18.222180
10.197156,13.752454,18.091722
10.193014,14.155764,18.140961
9.991551,14.519998,18.259678
9.785565,14.900722,18.399200
9.956219,15.200362,18.683318
10.212167,15.490787,19.116743
10.316667,15.802943,19.318626
10.375952,16.178182,19.263909
10.459429,16.565889,19.104119
10.488804,16.903387,18.797185
10.457645,17.221907,18.430859
10.428682,17.590771,18.127483
10.414386,18.019598,17.869295
10.390667,18.476863,17.617149
10.353305,18.925115,17.366437
10.344377,19.337262,17.130987
10.384082,19.715004,16.900921
10.399745,20.105860,16.612529
10.377600,20.535158,16.392282
10.306779,21.014754,16.343746
10.208883,21.492654,16.456304
10.096815,21.918975,16.648106
10.001838,22.320069,16.881447
9.943729,22.750526,17.106776
9.911515,23.213577,17.278512
9.883544,23.687472,17.379752
9.857014,24.163025,17.427430
9.846748,24.640705,17.448798
9.848805,25.121764,17.449898
9.850583,25.601969,17.423146
9.846450,26.077456,17.369240
9.838956,26.551489,17.306270
9.832955,27.028154,17.251450
9.829045,27.505963,17.199386
9.823290,27.981514,17.136791
9.809783,28.456707,17.067842
9.797849,28.934659,17.013384
9.800487,29.413655,16.978148
9.808344,29.889496,16.933156
9.808155,30.358312,16.849841
9.804639,30.819452,16.729285
9.803153,31.274734,16.581596
9.802588,31.725822,16.417467
9.800569,32.173508,16.248320
9.799989,32.619899,16.083155
9.802466,33.070958,15.926843
9.805547,33.528575,15.776491
9.820484,33.976710,15.611238
9.831793,34.402598,15.406383
9.837105,34.805733,15.161170
9.859786,35.187086,14.882690
9.877431,35.554923,14.576174
9.889782,35.920977,14.268560
9.901721,36.293466,13.978245
9.913089,36.667813,13.687408
9.919332,37.040934,13.380396
9.912428,37.436306,13.120473
9.907727,37.881554,12.996622
9.920376,38.365920,12.992181
9.932706,38.851348,13.008990
9.932237,39.321446,12.996187
9.882353,39.909433,13.000000
10.352941,0.000000,13.000000
10.362586,0.478565,12.996270
10.359335,0.970915,13.000620
10.364610,1.418730,13.009428
10.386348,1.927120,12.980542
10.359258,2.441914,12.992350
10.411416,2.784375,13.207883
10.407725,2.901881,13.646857
10.366382,2.937585,14.148821
10.359526,2.989524,14.620616
10.368193,3.036919,15.085189
10.321792,3.063903,15.558364
10.272699,3.111393,16.030336
10.257423,3.259225,16.466308
10.259996,3.525659,16.851018
10.254733,3.855191,17.204003
10.235279,4.213968,17.520287
10.255593,4.620009,17.752217
10.301734,5.091160,17.841263
10.333861,5.584203,17.831693
10.347940,6.047998,17.795897
10.387509,6.493222,17.739172
10.446457,6.965093,17.605976
10.468636,7.458563,17.439745
10.443313,7.909908,17.413590
10.441498,8.273740,17.643671
10.475435,8.586297,18.028874
10.393766,8.912290,18.383046
10.360330,9.285437,18.624209
10.400534,9.717420,18.705199
10.449386,10.196199,18.631539
10.470294,10.675915,18.571062
10.525598,11.132188,18.689090
10.497401,11.568660,18.892481
10.444290,11.996915,19.028622
10.492811,12.420571,19.005819
10.560974,12.854826,18.809526
10.575455,13.311750,18.557007
10.629350,13.762460,18.442710
10.635281,14.156775,18.482977
10.442777,14.476266,18.561329
10.195531,14.816347,18.708576
10.322471,15.121110,19.089821
10.560449,15.358082,19.609862
10.638334,15.683047,19.861516
10.672567,16.113847,19.839134
10.745456,16.530055,19.680570
10.779608,16.860055,19.367212
10.768139,17.137017,18.978904
10.755219,17.455419,18.637448
10.750904,17.854431,18.351400
10.736231,18.300370,18.087858
10.702511,18.752208,17.839557
10.682541,19.184811,17.623458
10.704188,19.586064,17.421366
10.705164,19.989303,17.156030
10.686575,20.413499,16.923747
10.646922,20.868877,16.825271
10.604518,21.337902,16.866341
10.548640,21.796552,16.970962
10.491727,22.237886,17.110452
10.454747,22.684958,17.260524
10.433761,23.149516,17.386223
10.407968,23.623570,17.466158
10.379639,24.099703,17.498829
10.368937,24.578264,17.504082
10.370911,25.059555,17.496428
10.370972,25.540466,17.472446
10.364554,26.018037,17.425427
10.356061,26.493461,17.363372
10.349879,26.969838,17.303078
10.344690,27.447389,17.248855
10.336159,27.924005,17.192053
10.320028,28.399664,17.130996
10.306869,28.877214,17.079811
10.308613,29.357549,17.045504
10.314614,29.835994,17.003690
10.310646,30.307461,16.926356
10.303350,30.771220,16.810989
10.298829,31.228627,16.666484
10.295556,31.681014,16.502583
10.291993,32.129417,16.330487
10.289681,32.576164,16.160308
10.289832,33.026339,15.997176
10.290141,33.482365,15.840682
10.301969,33.933746,15.675654
10.309597,34.367807,15.479913
10.309708,34.777610,15.240324
10.327603,35.161069,14.955462
10.341940,35.528180,14.641286
10.351024,35.898777,14.337775
10.359862,36.280825,14.058299
10.368515,36.659319,13.763723
10.372455,37.026242,13.434644
10.365833,37.410594,13.149268
10.359814,37.847905,13.004776
10.368105,38.328810,12.985370
10.379046,38.816975,13.002663
10.379978,39.293508,13.001485
10.352941,39.909433,13.000000
10.823529,0.000000,13.000000
10.832340,0.486943,12.987553
10.829359,0.959824,13.016399
10.834168,1.432878,12.996924
10.854724,1.946359,12.965483
10.829598,2.422578,13.029225
10.871433,2.719965,13.302896
10.863212,2.820525,13.764181
10.832840,2.853332,14.270102
10.832302,2.894068,14.747539
10.841435,2.930340,15.219139
10.804972,2.955460,15.703046
10.771755,3.019942,16.178705
10.777380,3.183296,16.614114
10.792028,3.447050,17.004706
10.788740,3.771923,17.372631
10.775692,4.136830,17.697497
10.808102,4.550257,17.920618
10.856504,5.017516,18.006632
10.879663,5.502750,18.013777
10.885741,5.969442,18.001466
10.929207,6.421429,17.951952
10.983834,6.891063,17.804026
10.985213,7.377245,17.619015
10.960425,7.826428,17.584853
10.971457,8.201845,17.781454
11.012920,8.528595,18.121421
10.954510,8.853812,18.491750
10.888517,9.222417,18.773852
10.919823,9.659477,18.849690
10.981474,10.146904,18.765448
11.002682,10.632299,18.717175
11.041196,11.088745,18.852393
10.995925,11.530987,19.095217
10.953077,11.964101,19.252396
11.010085,12.387714,19.211952
11.061224,12.819175,18.989036
11.058824,13.282274,18.740484
11.076260,13.749465,18.631049
11.090881,14.152379,18.693907
10.944352,14.455735,18.838710
10.677814,14.745215,19.018304
10.765646,14.995813,19.478366
10.984953,15.181269,19.997085
11.037183,15.517945,20.250712
11.042838,15.969861,20.273413
11.081529,16.409540,20.141559
11.098031,16.772963,19.853951
11.092881,17.078302,19.483973
11.092031,17.397784,19.133479
11.094924,17.774254,18.824723
11.088424,18.192475,18.541580
11.068293,18.623647,18.280806
11.058164,19.043808,18.054064
11.076624,19.439473,17.839449
11.060529,19.848366,17.572182
11.035396,20.282557,17.329038
11.014199,20.741258,17.192171
11.010184,21.213758,17.173612
10.996568,21.694252,17.217257
10.973878,22.169352,17.293232
10.957884,22.638481,17.385426
10.948245,23.110418,17.472382
10.927358,23.589116,17.534819
10.900628,24.071133,17.559689
10.890123,24.552641,17.557666
10.891421,25.033803,17.546428
10.890207,25.515204,17.525933
10.882806,25.995692,17.486162
10.874279,26.474359,17.427998
10.868303,26.952445,17.366612
10.862174,27.431416,17.313110
10.851460,27.910813,17.262443
10.833626,28.389693,17.207903
10.819858,28.868857,17.157823
10.820901,29.349490,17.121394
10.825266,29.828761,17.080362
10.818941,30.302083,17.006438
10.809314,30.767422,16.892124
10.802474,31.225666,16.746113
10.797200,31.678356,16.579214
10.792660,32.127021,16.402672
10.789287,32.574034,16.227403
10.787555,33.023599,16.058856
10.785018,33.478397,15.898094
10.793779,33.931606,15.733931
10.798859,34.370239,15.542811
10.795852,34.783034,15.304156
10.810769,35.168929,15.017487
10.822079,35.538736,14.703380
10.827161,35.913723,14.403211
10.834210,36.301305,14.127482
10.841410,36.683128,13.831426
10.843536,37.049763,13.496239
10.835499,37.429445,13.197688
10.826693,37.859132,13.029726
10.832638,38.333746,12.985040
10.843722,38.822229,12.995116
10.844647,39.304548,13.006201
10.823529,39.909433,13.000000
11.294118,0.000000,13.000000
11.300668,0.492231,12.986459
11.297866,0.962665,13.018542
11.302491,1.448813,12.994492
11.320533,1.964053,12.964377
11.299646,2.423370,13.041230
11.333455,2.695249,13.332448
11.336593,2.768268,13.815384
11.321646,2.784777,14.335718
11.323450,2.828786,14.813161
11.331751,2.874731,15.283519
11.318153,2.898446,15.779407
11.304948,2.948706,16.267208
11.322726,3.090503,16.700841
11.340805,3.334484,17.089569
11.338785,3.653821,17.469393
11.333643,4.022114,17.815470
11.366067,4.429776,18.053288
11.401584,4.878146,18.153598
11.417436,5.353118,18.178103
11.429405,5.831390,18.184651
11.474029,6.297790,18.146008
11.501555,6.760954,17.994593
11.472528,7.231480,17.782952
11.467142,7.687950,17.694739
11.490118,8.102962,17.832297
11.505012,8.467055,18.144103
11.483200,8.807550,18.511895
11.424512,9.183620,18.778571
11.480404,9.628737,18.823520
11.545588,10.119027,18.749987
11.535088,10.598236,18.758814
11.523679,11.049236,18.939972
11.456424,11.495012,19.213095
11.458759,11.934209,19.373492
11.544497,12.358149,19.299750
11.574703,12.785923,19.048983
11.554089,13.251921,18.800917
11.519394,13.740130,18.704870
11.537279,14.157760,18.816206
11.456498,14.448990,19.081938
11.202774,14.653873,19.372692
11.269109,14.809178,19.823259
11.445450,14.990726,20.240867
11.474314,15.338699,20.474024
11.459105,15.791686,20.552285
11.458216,16.254370,20.469545
11.451310,16.667670,20.226376
11.447291,17.029755,19.893546
11.454692,17.372938,19.550061
11.461175,17.731446,19.223855
11.459943,18.116546,18.918599
11.455457,18.518461,18.637873
11.465325,18.914467,18.383551
11.491067,19.298201,18.137361
11.463414,19.710665,17.861104
11.430836,20.155986,17.609438
11.420339,20.625317,17.435296
11.438110,21.103575,17.355603
11.447207,21.589262,17.347759
11.445092,22.076499,17.386061
11.442197,22.559255,17.447238
11.439841,23.038498,17.511669
11.424741,23.520694,17.564260
11.401697,24.007332,17.594797
11.391189,24.493076,17.605688
11.391489,24.977551,17.604097
11.390691,25.462059,17.589353
11.384972,25.946129,17.555680
11.378156,26.429016,17.504629
11.373143,26.911567,17.449407
11.367189,27.395161,17.400664
11.356522,27.879156,17.353552
11.339736,28.362305,17.300346
11.327125,28.845178,17.248481
11.328085,29.329530,17.209819
11.331165,29.813944,17.171878
11.324767,30.292782,17.104126
11.315435,30.761972,16.991285
11.307968,31.222771,16.840497
11.302199,31.677898,16.667017
11.297766,32.129429,16.485434
11.295051,32.579405,16.306835
11.293555,33.031768,16.135491
11.289506,33.490431,15.973229
11.295907,33.948754,15.808761
11.300235,34.391233,15.615145
11.296504,34.806530,15.373263
11.310044,35.198009,15.089822
11.319304,35.575400,14.781349
11.319981,35.954212,14.478170
11.325489,36.341982,14.194169
11.331114,36.725965,13.898866
11.332504,37.098516,13.574443
11.323086,37.481161,13.273198
11.311280,37.905577,13.074550
11.317498,38.373101,12.991630
11.329149,38.860437,12.986630
11.327970,39.348337,13.010237
11.294118,39.909433,13.000000
11.764706,0.000000,13.000000
11.768032,0.497312,12.985867
11.765757,0.965789,13.019332
11.769762,1.463205,12.993854
11.782507,1.980784,12.963556
11.768139,2.428770,13.043757
11.792538,2.687045,13.338107
11.806151,2.746364,13.830086
11.803689,2.750996,14.362800
11.807719,2.798217,14.843155
11.813942,2.854922,15.310851
11.820468,2.882130,15.810814
11.822573,2.921367,16.308088
11.841041,3.047797,16.746296
11.856275,3.283689,17.135636
11.856133,3.601584,17.516570
11.856357,3.969299,17.870610
11.876429,4.373660,18.120431
11.891966,4.815145,18.232726
11.900344,5.290372,18.261125
11.914270,5.780880,18.262463
11.946627,6.261964,18.215538
11.949507,6.721405,18.070786
11.910173,7.175978,17.868521
11.925875,7.645169,17.761086
11.955606,8.089166,17.884601
11.946088,8.467439,18.196005
11.952646,8.819355,18.548219
11.918301,9.207325,18.759672
11.975096,9.672980,18.777324
12.025773,10.174053,18.744156
12.003084,10.646690,18.819827
11.961452,11.091643,19.024449
11.885362,11.525573,19.273584
11.915218,11.970240,19.407751
12.000481,12.414075,19.306454
12.012594,12.853056,19.045521
11.990499,13.314950,18.814066
11.933709,13.791421,18.754268
11.948644,14.207462,18.918600
11.922292,14.474781,19.241237
11.728172,14.589811,19.614264
11.765792,14.660042,20.005869
11.876009,14.844922,20.309951
11.894499,15.193670,20.535983
11.883563,15.644417,20.672164
11.863928,16.122953,20.650367
11.846395,16.573562,20.454613
11.847370,16.976208,20.154284
11.859814,17.332578,19.818251
11.865698,17.673722,19.478914
11.865255,18.031607,19.154055
11.870007,18.413065,18.852868
11.895710,18.800449,18.571852
11.932958,19.192771,18.303488
11.906820,19.613569,18.036428
11.873998,20.058573,17.791439
11.868747,20.523097,17.594518
11.893505,20.996203,17.469591
11.907663,21.480945,17.423629
11.911161,21.974332,17.436862
11.912343,22.466376,17.476976
11.913239,22.952493,17.522789
11.903147,23.438419,17.566220
11.884173,23.928233,17.603443
11.875271,24.417983,17.629146
11.876425,24.906593,17.637430
11.877537,25.394664,17.625961
11.874914,25.882044,17.595177
11.871195,26.368671,17.549774
11.868331,26.855406,17.500259
11.863504,27.343098,17.454273
11.854059,27.830803,17.408041
11.840016,28.317536,17.356154
11.830364,28.804236,17.305295
11.832399,29.292708,17.265819
11.834710,29.781816,17.228344
11.828670,30.265519,17.164533
11.820453,30.739054,17.055916
11.812899,31.203562,16.905972
11.806869,31.661843,16.729570
11.802392,32.116331,16.544311
11.799713,32.569190,16.363151
11.797920,33.024605,16.190314
11.792365,33.487517,16.027847
11.796303,33.950381,15.862895
11.799332,34.396441,15.667402
11.793634,34.815243,15.424287
11.802654,35.211009,15.142949
11.808353,35.593979,14.838218
11.805423,35.976250,14.532884
11.808485,36.363957,14.241232
11.809200,36.749441,13.945394
11.806409,37.127140,13.630163
11.796722,37.514130,13.329898
11.785368,37.937184,13.110097
11.790477,38.400134,12.997753
11.798708,38.886403,12.980421
11.794928,39.379248,13.013075
11.764706,39.909433,13.000000
12.235294,0.000000,13.000000
12.234944,0.503660,12.980538
12.233899,0.958410,13.028086
12.236220,1.472004,12.988627
12.240104,1.994827,12.953522
12.234393,2.425304,13.049679
12.244847,2.678313,13.350466
12.256476,2.753691,13.831180
12.259704,2.764327,14.364726
12.268960,2.804657,14.855270
12.271517,2.858375,15.323922
12.284484,2.894745,15.815376
12.292234,2.950997,16.311178
12.302770,3.098402,16.762727
12.313059,3.353208,17.160219
12.315498,3.676852,17.528715
12.316255,4.042035,17.862459
12.317039,4.450975,18.104027
12.313521,4.907247,18.214130
12.312931,5.395751,18.227845
12.316119,5.887914,18.197400
12.325713,6.366063,18.125023
12.319740,6.825772,17.994311
12.297217,7.283696,17.841991
12.325347,7.757763,17.786761
12.357909,8.187300,17.958550
12.343678,8.541818,18.296966
12.362681,8.890488,18.629214
12.350186,9.292199,18.785789
12.366396,9.780478,18.789361
12.397671,10.289413,18.797309
12.391477,10.764556,18.919645
12.354880,11.215008,19.111843
12.291144,11.638883,19.289381
12.306358,12.083062,19.373268
12.355181,12.550307,19.263744
12.354524,13.013587,19.013610
12.346459,13.470819,18.815269
12.308357,13.907804,18.815901
12.316659,14.295572,19.014300
12.319853,14.528567,19.280796
12.219534,14.606614,19.576598
12.197246,14.646391,19.923836
12.232369,14.794382,20.195246
12.261258,15.125631,20.451223
12.285706,15.578613,20.635395
12.280266,16.059063,20.671329
12.274770,16.515089,20.511145
12.288578,16.914914,20.221840
12.302365,17.257570,19.884370
12.303818,17.583459,19.537110
12.300207,17.929414,19.200248
12.303983,18.310966,18.884868
12.332124,18.720185,18.590714
12.377447,19.149081,18.321461
12.366416,19.582852,18.087780
12.345045,20.012952,17.869561
12.342522,20.451043,17.671906
12.362874,20.909350,17.526542
12.370690,21.395702,17.462105
12.369547,21.896490,17.461833
12.369009,22.394718,17.487118
12.371184,22.886309,17.517099
12.365139,23.376096,17.551888
12.350010,23.867110,17.589150
12.345186,24.359182,17.617824
12.349921,24.850601,17.626908
12.354081,25.341063,17.613643
12.355078,25.830700,17.581483
12.355474,26.319488,17.536587
12.356111,26.807984,17.486734
12.353341,27.296626,17.437701
12.345665,27.785032,17.389253
12.335190,28.273067,17.340079
12.330008,28.761877,17.294638
12.334430,29.252250,17.256450
12.336683,29.741847,17.214443
12.330342,30.225943,17.148286
12.322698,30.701750,17.045471
12.314680,31.169309,16.905334
12.307760,31.629448,16.733700
12.302417,32.084557,16.547662
12.297734,32.537701,16.364293
12.293296,32.993483,16.190322
12.285125,33.456348,16.027376
12.285998,33.919925,15.862987
12.285582,34.368926,15.671628
12.274014,34.791471,15.432800
12.273195,35.187328,15.148831
12.272851,35.569588,14.841748
12.267621,35.954490,14.540279
12.266868,36.345277,14.250821
12.257998,36.731645,13.951498
12.245030,37.108647,13.631739
12.235964,37.496048,13.331353
12.229552,37.921154,13.112647
12.229741,38.385026,12.997733
12.228888,38.872316,12.979179
12.222781,39.368021,13.014092
12.235294,39.909433,13.000000
12.705882,0.000000,13.000000
12.701802,0.505326,12.977424
12.702404,0.952013,13.033403
12.702125,1.469793,12.986025
12.695604,1.996287,12.946345
12.699976,2.424037,13.047277
12.691786,2.685973,13.345185
12.697753,2.783768,13.810293
12.710113,2.806191,14.338157
12.724737,2.841384,14.834065
12.720502,2.887547,15.304285
12.737430,2.927736,15.784890
12.754677,2.999500,16.274308
12.758528,3.171438,16.734728
12.761410,3.450328,17.136321
12.764820,3.782784,17.489850
12.767980,4.144025,17.801604
12.752570,4.556501,18.032335
12.729882,5.032366,18.133307
12.717748,5.536313,18.126845
12.706174,6.023375,18.066377
12.691096,6.489658,17.974609
12.679614,6.953635,17.853625
12.677663,7.427215,17.740998
12.708071,7.893506,17.741990
12.737172,8.287172,17.964539
12.725969,8.612206,18.335113
12.754931,8.946162,18.655512
12.766342,9.346664,18.798640
12.732631,9.841510,18.812919
12.740960,10.347430,18.832912
12.745988,10.831969,18.947597
12.721843,11.300386,19.108634
12.685880,11.727211,19.235215
12.682933,12.164797,19.291844
12.684193,12.643138,19.195048
12.664303,13.131393,18.961925
12.669052,13.586525,18.783224
12.660101,13.991637,18.822499
12.661824,14.349607,19.025156
12.697065,14.558508,19.194406
12.714093,14.669984,19.353917
12.613338,14.754370,19.677179
12.560772,14.855939,19.979343
12.597510,15.159653,20.266361
12.655181,15.604689,20.460692
12.670135,16.066275,20.523749
12.683265,16.502436,20.375272
12.709371,16.877596,20.076816
12.722003,17.203306,19.733736
12.719371,17.529161,19.388132
12.713651,17.884323,19.052785
12.714513,18.283410,18.735380
12.738001,18.724314,18.437648
12.781794,19.184987,18.166642
12.783927,19.621583,17.957774
12.775961,20.036811,17.764760
12.776996,20.459481,17.580551
12.794517,20.919710,17.442044
12.801597,21.411084,17.394048
12.801391,21.909803,17.412388
12.804308,22.405098,17.450610
12.811319,22.897427,17.488856
12.810490,23.387440,17.528283
12.800017,23.875426,17.563027
12.799672,24.366375,17.584205
12.808438,24.858692,17.586756
12.816323,25.350121,17.569325
12.821539,25.840023,17.533543
12.826527,26.328494,17.484564
12.831322,26.816303,17.430383
12.831681,27.303403,17.377064
12.826703,27.789475,17.325547
12.820065,28.275208,17.276248
12.819405,28.762869,17.233250
12.826766,29.252935,17.196254
12.830170,29.740587,17.150656
12.824347,30.221390,17.079876
12.817296,30.695253,16.977907
12.808817,31.161946,16.844082
12.801438,31.621325,16.678574
12.796160,32.075444,16.496021
12.790375,32.527394,16.314351
12.783728,32.981664,16.141428
12.773011,33.441302,15.978404
12.770612,33.902083,15.813467
12.765984,34.350144,15.624777
12.747551,34.772076,15.390030
12.736793,35.164873,15.102582
12.730409,35.542990,14.791444
12.722285,35.927109,14.494543
12.716926,36.319275,14.210559
12.698292,36.704596,13.909135
12.674261,37.078346,13.582638
12.665255,37.465322,13.286151
12.664026,37.895152,13.087439
12.657797,38.364131,12.993846
12.646289,38.853120,12.983222
12.637424,39.347502,13.012459
12.705882,39.909433,13.000000
13.176471,0.000000,13.000000
13.169003,0.495596,12.985259
13.171222,0.961427,13.020716
13.167832,1.451914,12.995269
13.151956,1.974823,12.957365
13.166841,2.439353,13.021248
13.136129,2.731192,13.289404
13.143856,2.829906,13.752876
13.179114,2.854951,14.275152
13.195004,2.901216,14.758769
13.180231,2.947769,15.227123
13.210857,2.976185,15.705842
13.252919,3.030610,16.190859
13.259043,3.195295,16.643089
13.251604,3.480542,17.034156
13.253022,3.819540,17.381462
13.266721,4.175923,17.696318
13.247487,4.581173,17.932923
13.205846,5.060127,18.028251
13.180111,5.568198,18.011107
13.159896,6.048916,17.951084
13.125866,6.507326,17.867701
13.099419,6.977436,17.742399
13.099121,7.461988,17.610693
13.120200,7.913210,17.598558
13.135818,8.284268,17.818898
13.122513,8.604431,18.202552
13.171210,8.922646,18.534793
13.213386,9.294855,18.731902
13.151632,9.761976,18.791235
13.131333,10.251808,18.775264
13.113727,10.745979,18.802355
13.082910,11.235060,18.925622
13.082700,11.675526,19.082870
13.100295,12.104726,19.182373
13.064730,12.573138,19.119052
13.008720,13.070131,18.895842
13.009153,13.526600,18.692572
13.008731,13.938766,18.697441
13.006960,14.295366,18.868126
13.103970,14.516928,18.981325
13.260711,14.720382,19.117944
13.104777,14.921939,19.445144
12.930271,15.037252,19.767658
12.937532,15.316702,20.033776
12.985334,15.725492,20.169491
12.994284,16.141075,20.200560
13.012699,16.542950,20.029442
13.042471,16.900403,19.707752
13.054732,17.233217,19.362177
13.053056,17.587369,19.031986
13.051512,17.977207,18.717015
13.057568,18.404355,18.414934
13.079069,18.859603,18.117240
13.109580,19.312564,17.823209
13.107178,19.728858,17.598698
13.102544,20.144149,17.405264
13.111789,20.594725,17.241163
13.144540,21.092593,17.145429
13.173855,21.587207,17.165069
13.194506,22.063073,17.251656
13.215377,22.540384,17.347835
13.235081,23.024717,17.433724
13.242107,23.508333,17.499415
13.237638,23.988974,17.534114
13.240166,24.474478,17.542235
13.251442,24.964560,17.534696
13.263327,25.454393,17.513207
13.273297,25.941239,17.473217
13.282778,26.425906,17.417157
13.291633,26.910434,17.357861
13.295944,27.394415,17.303489
13.294499,27.876211,17.250347
13.291252,28.356459,17.195587
13.293796,28.839296,17.146733
13.303913,29.326572,17.108874
13.309805,29.811443,17.065135
13.306337,30.287365,16.991490
13.300330,30.754871,16.881048
13.291697,31.215536,16.739552
13.285193,31.671583,16.575097
13.282357,32.124617,16.400506
13.279072,32.575781,16.227051
13.273447,33.028545,16.058939
13.261757,33.485002,15.897311
13.256451,33.940623,15.728599
13.248667,34.381406,15.533243
13.226204,34.795966,15.295690
13.211059,35.184497,15.007843
13.201343,35.558803,14.695784
13.188115,35.937033,14.397741
13.178177,36.323721,14.113922
13.155052,36.705685,13.815707
13.125805,37.079111,13.494013
13.115373,37.469918,13.211841
13.115235,37.907290,13.045839
13.104101,38.383328,12.989857
13.085159,38.872574,12.992306
13.072779,39.360182,13.007393
13.176471,39.909433,13.000000
13.647059,0.000000,13.000000
13.637251,0.478638,13.000064
13.640589,0.978802,12.996108
13.634574,1.424553,13.012057
13.612222,1.935653,12.983090
13.635117,2.457127,12.982339
13.583155,2.798847,13.190143
13.592044,2.894856,13.646831
13.647607,2.921632,14.158781
13.662018,2.988489,14.621629
13.641197,3.042509,15.085657
13.687918,3.056874,15.564536
13.751725,3.083898,16.041909
13.764824,3.223374,16.477025
13.754292,3.497887,16.853606
13.757537,3.836654,17.201807
13.783603,4.190008,17.529154
13.769816,4.580970,17.778037
13.719086,5.042618,17.875939
13.684620,5.538895,17.860212
13.663167,6.009013,17.822612
13.621707,6.457095,17.770775
13.579614,6.925310,17.640927
13.568144,7.411434,17.457503
13.576750,7.858111,17.390494
13.577753,8.234281,17.579106
13.557348,8.567466,17.955163
13.626732,8.889834,18.313141
13.686669,9.238415,18.570672
13.612734,9.647932,18.675784
13.569902,10.115245,18.607200
13.521916,10.607278,18.532491
13.473877,11.094200,18.620974
13.501392,11.542867,18.846894
13.556043,11.966159,19.018177
13.498934,12.400152,18.994970
13.405925,12.865748,18.782660
13.387915,13.324130,18.521170
13.370288,13.774267,18.428576
13.366666,14.160418,18.542248
13.533184,14.449155,18.660220
13.788046,14.770801,18.843196
13.637398,15.096386,19.231564
13.356895,15.308027,19.587771
13.291304,15.578079,19.769045
13.277514,15.921298,19.780686
13.246763,16.272033,19.724877
13.254803,16.636875,19.505104
13.286230,16.995284,19.161861
13.303913,17.361518,18.823802
13.309087,17.765801,18.520149
13.318108,18.204575,18.238578
13.338363,18.657622,17.963328
13.363849,19.101134,17.666529
13.377051,19.511563,17.337931
13.356683,19.894064,17.072406
13.348908,20.323928,16.866237
13.377959,20.830231,16.741731
13.451471,21.370448,16.733894
13.525703,21.850707,16.861640
13.582379,22.288308,17.044779
13.629380,22.738840,17.218829
13.664190,23.208280,17.362817
13.678839,23.681763,17.457750
13.679907,24.155211,17.496357
13.684050,24.634043,17.497308
13.696777,25.118772,17.483058
13.711733,25.603457,17.456686
13.725216,26.084092,17.410449
13.737960,26.562486,17.347795
13.749817,27.041692,17.286223
13.757084,27.520949,17.232844
13.758067,27.997420,17.178037
13.756986,28.471587,17.117026
13.761571,28.948518,17.061983
13.773612,29.430802,17.022994
13.781414,29.911113,16.980585
13.780038,30.381444,16.903091
13.774408,30.841559,16.781632
13.765292,31.294986,16.628283
13.759767,31.746571,16.462010
13.759563,32.197446,16.294959
13.759444,32.647113,16.130529
13.755859,33.098505,15.968804
13.744313,33.553395,15.810607
13.737292,34.003728,15.638810
13.728350,34.435011,15.433634
13.704485,34.840795,15.188721
13.688943,35.225474,14.901866
13.678510,35.597249,14.591381
13.660320,35.968639,14.288636
13.646822,36.346931,14.000908
13.624053,36.725662,13.707181
13.596423,37.102518,13.396339
13.584578,37.500082,13.133207
13.581643,37.945534,13.002590
13.568004,38.429520,12.988282
13.547157,38.918802,13.003935
13.532495,39.396842,13.000002
13.647059,39.909433,13.000000
14.117647,0.000000,13.000000
14.107390,0.464660,13.010773
14.110887,0.983798,12.977118
14.104027,1.399883,13.024520
14.079450,1.893280,13.008738
14.103883,2.447378,12.955951
14.039666,2.850879,13.079798
14.029670,2.986857,13.481878
14.074341,3.033949,13.968039
14.090666,3.112781,14.421530
14.079754,3.174113,14.882487
14.131923,3.194693,15.348648
14.191237,3.222111,15.807407
14.209066,3.347230,16.231489
14.214533,3.603960,16.606455
14.232113,3.931859,16.956498
14.263620,4.284715,17.277913
14.253537,4.669027,17.523913
14.208295,5.111908,17.628474
14.174767,5.591684,17.618334
14.150951,6.050930,17.591222
14.109377,6.485162,17.560650
14.068146,6.941903,17.445106
14.059780,7.426717,17.258526
14.072496,7.882861,17.190650
14.076020,8.277154,17.376375
14.050565,8.620766,17.742298
14.123265,8.974201,18.095601
14.160877,9.340507,18.321206
14.062708,9.699323,18.423830
14.022463,10.147829,18.339785
13.987353,10.620812,18.263468
13.940480,11.076370,18.349625
13.966702,11.521224,18.574494
14.006727,11.935495,18.740550
13.932964,12.317679,18.737694
13.826054,12.724275,18.552092
13.796812,13.180479,18.250086
13.756921,13.657523,18.070751
13.747387,14.073236,18.127951
13.945304,14.452350,18.260615
14.185886,14.861975,18.433432
14.063899,15.234555,18.880775
13.764252,15.571813,19.331600
13.629918,15.861606,19.428865
13.542565,16.145608,19.310154
13.461353,16.438272,19.155818
13.455057,16.776960,18.885436
13.492011,17.154639,18.533750
13.520819,17.567412,18.214179
13.537136,18.022921,17.940931
13.559380,18.502798,17.691841
13.594031,18.968601,17.439327
13.623153,19.386646,17.139458
13.621482,19.748834,16.782573
13.584962,20.102318,16.488990
13.583155,20.552636,16.296022
13.651357,21.103772,16.252181
13.787274,21.645890,16.372729
13.918450,22.080683,16.620429
14.013228,22.479784,16.890111
14.081716,22.909135,17.120871
14.124853,23.364435,17.291519
14.142748,23.829601,17.393701
14.146724,24.299953,17.439798
14.152119,24.774943,17.451234
14.165844,25.253460,17.440421
14.181212,25.730571,17.406480
14.194729,26.203923,17.350054
14.208195,26.676340,17.284828
14.220959,27.150026,17.226764
14.228284,27.623119,17.173943
14.228688,28.093350,17.115379
14.228050,28.562630,17.052945
14.234009,29.035532,17.001137
14.246391,29.512208,16.962320
14.253308,29.985347,16.912810
14.251275,30.448966,16.826657
14.244112,30.903204,16.700378
14.233460,31.351405,16.545351
14.227400,31.797791,16.379418
14.227091,32.243079,16.214176
14.226598,32.687861,16.052526
14.222461,33.136366,15.896122
14.210625,33.589711,15.744330
14.203566,34.035906,15.575947
14.195591,34.460221,15.369023
14.170178,34.859993,15.120782
14.152719,35.240105,14.834370
14.142077,35.608560,14.525938
14.122320,35.976811,14.222791
14.106593,36.350732,13.934936
14.083082,36.726484,13.642355
14.057381,37.102709,13.333736
14.045989,37.501477,13.080403
14.040001,37.951204,12.974962
14.024155,38.441240,12.990583
14.004509,38.929711,13.013579
13.991052,39.398464,12.993215
14.117647,39.909433,13.000000
14.588235,0.000000,13.000000
14.579152,0.457903,13.012378
14.581840,0.968592,12.972790
14.576017,1.383039,13.026247
14.553030,1.857294,13.023302
14.572329,2.401331,12.953804
14.507158,2.861236,12.990214
14.456034,3.095393,13.275550
14.453023,3.192395,13.711394
14.473485,3.273145,14.168048
14.486696,3.338811,14.629623
14.536111,3.385477,15.074258
14.573732,3.439536,15.509942
14.593516,3.566768,15.929357
14.626061,3.807628,16.311855
14.664374,4.119189,16.661133
14.695293,4.471818,16.960855
14.684915,4.858603,17.189727
14.652534,5.293517,17.298486
14.627331,5.762844,17.293260
14.598379,6.217372,17.257312
14.557446,6.646072,17.220403
14.533430,7.095126,17.131674
14.551447,7.580941,17.016397
14.587037,8.051202,17.026611
14.607342,8.462941,17.242537
14.579461,8.811206,17.600713
14.624966,9.198691,17.889468
14.611227,9.603615,17.995936
14.481422,9.959679,18.051899
14.470527,10.411987,18.005061
14.501067,10.868057,18.054205
14.485760,11.284963,18.184574
14.473000,11.705525,18.287441
14.425849,12.095700,18.336033
14.329858,12.448510,18.307525
14.241370,12.818970,18.153901
14.225798,13.271114,17.870708
14.178426,13.734632,17.680809
14.154151,14.152065,17.705375
14.317942,14.585294,17.818157
14.464592,15.007601,17.916055
14.330474,15.331720,18.344288
14.071393,15.731252,18.884895
13.920975,16.079409,18.964645
13.791884,16.350370,18.773599
13.674164,16.618362,18.554610
13.661513,16.955593,18.256093
13.712693,17.370309,17.919381
13.757750,17.829353,17.629765
13.787860,18.316124,17.383444
13.822167,18.806953,17.151784
13.862246,19.261700,16.902019
13.887977,19.653590,16.590113
13.880195,19.991203,16.228958
13.844672,20.338716,15.958752
13.873691,20.806678,15.843461
14.006577,21.354256,15.939601
14.212185,21.832185,16.202782
14.387249,22.217017,16.529126
14.502372,22.611399,16.832459
14.576255,23.044942,17.072888
14.617634,23.499095,17.231334
14.634208,23.962284,17.317773
14.637972,24.431491,17.365293
14.643077,24.903390,17.390632
14.656153,25.376018,17.384643
14.669714,25.846192,17.340614
14.681382,26.314027,17.273857
14.694270,26.782546,17.209888
14.706765,27.251693,17.157648
14.712711,27.718098,17.104460
14.711290,28.181240,17.042564
14.710302,28.645650,16.983285
14.716814,29.114952,16.938746
14.727734,29.585151,16.896473
14.731149,30.048379,16.831688
14.725940,30.502748,16.733492
14.715869,30.950291,16.607250
14.702914,31.392728,16.459404
14.694935,31.831934,16.297059
14.692635,32.268655,16.130398
14.689811,32.706063,15.968402
14.683661,33.149895,15.818034
14.670199,33.598586,15.675251
14.662428,34.038564,15.513939
14.654866,34.456012,15.312044
14.626072,34.849659,15.069701
14.604214,35.223121,14.787756
14.592741,35.586007,14.484374
14.572920,35.951906,14.188806
14.554658,36.323863,13.907272
14.527196,36.695243,13.617673
14.501013,37.064441,13.309703
14.492488,37.457330,13.061385
14.485022,37.905697,12.969613
14.465245,38.394951,12.996530
14.446242,38.877730,13.018242
14.436880,39.337593,12.989148
14.588235,39.909433,13.000000
15.058824,0.000000,13.000000
15.050934,0.455346,13.007244
15.052400,0.940329,12.981965
15.048098,1.370483,13.017605
15.027314,1.830330,13.021191
15.039805,2.336404,12.970645
14.978185,2.824619,12.951635
14.891410,3.177283,13.093585
14.824649,3.360653,13.436991
14.835846,3.456149,13.883353
14.870648,3.525340,14.350512
14.921156,3.598479,14.783407
14.942485,3.685295,15.200211
14.961706,3.826031,15.610509
15.012333,4.061125,15.993448
15.061404,4.364645,16.337015
15.088915,4.719807,16.616326
15.078886,5.108278,16.828945
15.059745,5.536946,16.941614
15.047130,5.998909,16.945890
15.018264,6.453335,16.905154
14.979842,6.885315,16.858746
14.976512,7.333568,16.801643
15.025547,7.819730,16.774941
15.079271,8.296823,16.861633
15.100465,8.720836,17.076320
15.056088,9.073394,17.393396
15.055441,9.473857,17.595980
15.013424,9.902003,17.612175
14.889680,10.279991,17.649118
14.921181,10.732169,17.668476
15.000325,11.170247,17.823004
14.999347,11.565887,17.977576
14.946659,11.966826,17.948969
14.818329,12.342868,17.872078
14.705304,12.701825,17.799065
14.649121,13.083429,17.667567
14.663163,13.537217,17.446298
14.624788,13.973636,17.305350
14.581779,14.376076,17.318586
14.672647,14.808217,17.383701
14.707872,15.204885,17.393746
14.522814,15.437511,17.735113
14.280814,15.790153,18.265062
14.148944,16.178754,18.358559
14.037481,16.492753,18.188756
13.921190,16.791074,17.982313
13.921961,17.165232,17.702267
13.999089,17.633955,17.410839
14.061890,18.126083,17.156947
14.104170,18.607544,16.922573
14.143503,19.066756,16.678397
14.171954,19.487512,16.399922
14.183364,19.866831,16.067659
14.182507,20.220325,15.739270
14.176677,20.592837,15.569272
14.264676,21.069867,15.605125
14.462506,21.569867,15.849875
14.706821,21.982692,16.198951
14.896909,22.363066,16.543677
15.013166,22.782824,16.832047
15.082171,23.233357,17.051571
15.120660,23.696158,17.190190
15.136155,24.160749,17.256251
15.137577,24.623258,17.282171
15.138376,25.084777,17.290486
15.147799,25.548308,17.271701
15.160538,26.012251,17.218446
15.173392,26.475999,17.149881
15.187781,26.940523,17.089653
15.201257,27.404014,17.039722
15.207751,27.863066,16.986424
15.206851,28.318561,16.926282
15.206346,28.775984,16.871038
15.212126,29.237457,16.825103
15.219978,29.696817,16.769624
15.218701,30.146514,16.686619
15.209392,30.587984,16.576461
15.196545,31.024854,16.447663
15.181505,31.457625,16.304129
15.171483,31.886939,16.145761
15.168333,32.314522,15.980886
15.166163,32.745413,15.823855
15.160739,33.184462,15.683523
15.144822,33.624308,15.548752
15.132100,34.051593,15.388058
15.120402,34.456765,15.185740
15.087236,34.841065,14.952833
15.063038,35.207993,14.683263
15.051162,35.564815,14.390720
15.027619,35.922839,14.102920
15.004118,36.286987,13.824184
14.975195,36.653630,13.544761
14.954175,37.022641,13.262496
14.951909,37.417153,13.045897
14.944078,37.863214,12.974392
14.920372,38.343435,13.002674
14.900647,38.815136,13.018458
14.894453,39.266782,12.987811
15.058824,39.909433,13.000000
15.529412,0.000000,13.000000
15.521725,0.453766,12.998912
15.522069,0.907733,12.999788
15.518691,1.358384,13.002091
15.498353,1.811912,13.002806
15.506416,2.270234,12.997326
15.446663,2.746004,12.978635
15.354338,3.193394,12.996469
15.231358,3.500470,13.194924
15.204576,3.646902,13.590852
15.241591,3.721940,14.068127
15.305914,3.806001,14.512060
15.332747,3.915978,14.918820
15.348677,4.076901,15.307027
15.393370,4.322775,15.670881
15.434062,4.635241,16.001926
15.458101,4.996868,16.270416
15.451541,5.381417,16.476008
15.442137,5.799756,16.594852
15.443900,6.254324,16.616531
15.424803,6.709527,16.593500
15.392587,7.149014,16.561589
15.403967,7.601560,16.537832
15.474387,8.085263,16.562773
15.529276,8.557827,16.667020
15.522615,8.987782,16.820351
15.432158,9.345309,17.036763
15.382257,9.730336,17.169865
15.361471,10.142845,17.195453
15.308122,10.519801,17.297762
15.379862,10.944233,17.384129
15.434266,11.371541,17.498746
15.392314,11.772780,17.601544
15.325513,12.174682,17.530099
15.192863,12.560592,17.422106
15.084366,12.949271,17.330436
15.055831,13.362752,17.220399
15.096653,13.820347,17.070365
15.075502,14.247861,16.985325
15.019422,14.647201,16.991612
15.037809,15.066006,17.010468
15.000460,15.450803,16.970231
14.737305,15.605723,17.178638
14.466437,15.838937,17.602214
14.357946,16.231172,17.701571
14.299810,16.602114,17.601451
14.224535,16.959129,17.479712
14.258503,17.405079,17.264052
14.358755,17.933489,17.019045
14.429756,18.439219,16.782423
14.476775,18.891250,16.537346
14.513105,19.302589,16.259281
14.521571,19.688226,15.944590
14.517358,20.069480,15.607218
14.534150,20.461538,15.347302
14.575720,20.871772,15.319287
14.727633,21.348218,15.520964
14.968429,21.800345,15.877446
15.219815,22.204901,16.268936
15.405415,22.624477,16.602312
15.513491,23.062087,16.849580
15.576700,23.515652,17.035723
15.616857,23.983433,17.159428
15.633378,24.446019,17.205884
15.631317,24.894100,17.187518
15.624402,25.336826,17.144821
15.628245,25.786439,17.096201
15.642565,26.242967,17.038693
15.660456,26.701480,16.978656
15.678448,27.158894,16.923125
15.693749,27.613318,16.870519
15.702271,28.063530,16.816414
15.704007,28.511100,16.761084
15.704897,28.959649,16.707856
15.708968,29.408779,16.650871
15.712775,29.853060,16.575683
15.706797,30.287232,16.475679
15.693811,30.714345,16.354960
15.679457,31.138351,16.218897
15.663773,31.559274,16.072300
15.652920,31.977895,15.916140
15.650947,32.397522,15.757176
15.652628,32.823651,15.610180
15.650875,33.258026,15.480559
15.633336,33.686428,15.348288
15.612837,34.095703,15.178184
15.593222,34.483146,14.965129
15.556785,34.855039,14.735237
15.534828,35.216933,14.480468
15.523956,35.568812,14.201599
15.493079,35.913066,13.913918
15.462974,36.261614,13.627341
15.440710,36.625938,13.365573
15.437128,37.012407,13.148529
15.444798,37.427204,13.010866
15.437766,37.874392,12.978326
15.413671,38.339331,13.005612
15.393348,38.797250,13.015124
15.386774,39.242883,12.989020
15.529412,39.909433,13.000000
16.000000,0.000000,13.000000
15.992208,0.450512,12.992760
15.991824,0.881307,13.013691
15.988776,1.343509,12.990152
15.968256,1.793923,12.984934
15.974276,2.216754,13.017037
15.915238,2.663057,13.024643
15.836144,3.156589,12.973119
15.681469,3.583744,13.022173
15.598594,3.817263,13.323087
15.612884,3.916362,13.790499
15.688388,4.010034,14.244382
15.729474,4.135713,14.645461
15.744499,4.314011,15.011195
15.775733,4.574945,15.349662
15.801890,4.901861,15.664851
15.822555,5.271218,15.925345
15.820657,5.651730,16.127866
15.819663,6.060016,16.253754
15.836584,6.507641,16.295167
15.832131,6.962644,16.301639
15.809999,7.408745,16.302475
15.833547,7.865132,16.311724
15.916930,8.341351,16.355569
15.965033,8.802133,16.441168
15.923335,9.232523,16.521890
15.778310,9.598751,16.626521
15.686293,9.962100,16.710709
15.704595,10.343463,16.795719
15.736867,10.695010,16.993225
15.826922,11.092591,17.115020
15.822395,11.526222,17.117023
15.719867,11.938898,17.136051
15.653520,12.346428,17.082549
15.567333,12.735436,17.023735
15.485002,13.135394,16.966880
15.470237,13.572244,16.888878
15.526106,14.045148,16.789426
15.522010,14.486050,16.740093
15.461455,14.895029,16.738671
15.437205,15.318401,16.733519
15.398518,15.735443,16.706803
15.069292,15.889134,16.798684
14.704493,15.970822,17.030099
14.605283,16.335647,17.108681
14.605491,16.760468,17.078001
14.579400,17.171654,17.048317
14.646412,17.686636,16.899321
14.758251,18.253269,16.678004
14.828924,18.752017,16.435955
14.874824,19.174502,16.167201
14.906428,19.556128,15.860228
14.902843,19.926050,15.539499
14.894992,20.318512,15.241428
14.936535,20.748179,15.081648
15.025272,21.186891,15.185825
15.221014,21.651051,15.503781
15.476837,22.081426,15.928247
15.724288,22.503740,16.356422
15.903620,22.939028,16.671529
16.002320,23.371398,16.872884
16.059324,23.818717,17.013834
16.099288,24.282149,17.100554
16.114703,24.734938,17.113081
16.108891,25.168651,17.057642
16.096356,25.597153,16.979135
16.096698,26.035679,16.911681
16.112923,26.484501,16.855485
16.134542,26.935748,16.803408
16.154022,27.384208,16.748467
16.168623,27.828583,16.688564
16.176382,28.269337,16.628048
16.178514,28.708761,16.571588
16.180065,29.149057,16.516534
16.183062,29.587475,16.449001
16.183631,30.018794,16.357598
16.173990,30.440095,16.244189
16.158320,30.855532,16.115172
16.143569,31.269262,15.973738
16.128987,31.681074,15.825086
16.119126,32.091759,15.671644
16.118364,32.505143,15.517797
16.121219,32.925788,15.375565
16.120395,33.352907,15.247315
16.102577,33.769336,15.110710
16.078175,34.162329,14.930860
16.053420,34.533221,14.707984
16.014758,34.890885,14.474662
15.993860,35.244983,14.225957
15.983459,35.591567,13.954578
15.950112,35.926331,13.667192
15.920667,36.266243,13.382769
15.912002,36.637008,13.156648
15.928694,37.050377,13.026892
15.944227,37.490538,12.981644
15.939341,37.938448,12.984942
15.919583,38.386922,13.004210
15.901027,38.832381,13.008454
15.892920,39.274653,12.993320
16.000000,39.909433,13.000000
16.470588,0.000000,13.000000
16.463157,0.443722,12.993198
16.462616,0.869359,13.012936
16.459515,1.323794,12.990778
16.439763,1.768692,12.983990
16.445318,2.186295,13.015503
16.388154,2.616615,13.034363
16.317233,3.101488,12.982318
16.156642,3.590553,12.945172
16.029984,3.927638,13.120502
16.000216,4.096014,13.515353
16.057265,4.225840,13.941383
16.099689,4.365576,14.338111
16.125398,4.545186,14.703029
16.162956,4.805421,15.032091
16.185258,5.136592,15.333140
16.202036,5.512051,15.580448
16.203659,5.894872,15.777266
16.212622,6.298995,15.908809
16.244591,6.741421,15.965479
16.253825,7.194536,15.996466
16.245485,7.642771,16.030042
16.284564,8.097012,16.069677
16.374178,8.559261,16.122618
16.416000,9.006542,16.186802
16.355939,9.431727,16.235112
16.182933,9.811599,16.285317
16.065545,10.172705,16.339979
16.102373,10.541872,16.467467
16.166639,10.893471,16.690874
16.235110,11.297910,16.792207
16.200611,11.734475,16.737592
16.069595,12.137848,16.707096
